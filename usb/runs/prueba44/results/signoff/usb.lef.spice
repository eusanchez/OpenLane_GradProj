* NGSPICE file created from usb.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VGND VPWR VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311ai_1 abstract view
.subckt sky130_fd_sc_hd__o311ai_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_1 abstract view
.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4bb_1 abstract view
.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4b_1 abstract view
.subckt sky130_fd_sc_hd__nor4b_1 A B C D_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_1 abstract view
.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_2 abstract view
.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31ai_1 abstract view
.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfstp_1 abstract view
.subckt sky130_fd_sc_hd__dfstp_1 CLK D SET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4b_4 abstract view
.subckt sky130_fd_sc_hd__nand4b_4 A_N B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22oi_1 abstract view
.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_1 abstract view
.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_1 abstract view
.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_2 abstract view
.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22ai_4 abstract view
.subckt sky130_fd_sc_hd__o22ai_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_8 abstract view
.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_1 abstract view
.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a22o_1 abstract view
.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32oi_1 abstract view
.subckt sky130_fd_sc_hd__a32oi_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_2 abstract view
.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21bai_1 abstract view
.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_4 abstract view
.subckt sky130_fd_sc_hd__nand3b_4 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_1 abstract view
.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111a_1 abstract view
.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_2 abstract view
.subckt sky130_fd_sc_hd__nor4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2111ai_1 abstract view
.subckt sky130_fd_sc_hd__o2111ai_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_2 abstract view
.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_6 abstract view
.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221ai_1 abstract view
.subckt sky130_fd_sc_hd__o221ai_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4b_1 abstract view
.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2ai_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2ai_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_2 abstract view
.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3b_1 abstract view
.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_2 abstract view
.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o41a_1 abstract view
.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_4 abstract view
.subckt sky130_fd_sc_hd__nand4_4 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_1 abstract view
.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_2 abstract view
.subckt sky130_fd_sc_hd__and2b_2 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4b_1 abstract view
.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4b_1 abstract view
.subckt sky130_fd_sc_hd__nand4b_1 A_N B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_1 abstract view
.subckt sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4bb_1 abstract view
.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2b_2 abstract view
.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_2 abstract view
.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_2 abstract view
.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4b_2 abstract view
.subckt sky130_fd_sc_hd__nor4b_2 A B C D_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o2bb2a_1 abstract view
.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a41o_1 abstract view
.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111oi_1 abstract view
.subckt sky130_fd_sc_hd__a2111oi_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_2 abstract view
.subckt sky130_fd_sc_hd__o31a_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_2 abstract view
.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3b_2 abstract view
.subckt sky130_fd_sc_hd__nand3b_2 A_N B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211ai_4 abstract view
.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221oi_1 abstract view
.subckt sky130_fd_sc_hd__a221oi_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_2 abstract view
.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_4 abstract view
.subckt sky130_fd_sc_hd__nor4_4 A B C D VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_2 abstract view
.subckt sky130_fd_sc_hd__o221a_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

.subckt usb VGND VPWR clk_48 data_in[0] data_in[1] data_in[2] data_in[3] data_in[4]
+ data_in[5] data_in[6] data_in[7] data_in_valid data_out[0] data_out[1] data_out[2]
+ data_out[3] data_out[4] data_out[5] data_out[6] data_out[7] data_strobe data_toggle
+ direction_in endpoint[0] endpoint[1] endpoint[2] endpoint[3] handshake[0] handshake[1]
+ rst_n rx_j rx_se0 setup success transaction_active tx_en tx_j tx_se0 usb_address[0]
+ usb_address[1] usb_address[2] usb_address[3] usb_address[4] usb_address[5] usb_address[6]
+ usb_rst
XFILLER_39_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_7 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_258 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1270_ _1357_/A _1278_/S _0859_/C _1269_/Y _0917_/X VGND VGND VPWR VPWR _1549_/D
+ sky130_fd_sc_hd__o311ai_1
XFILLER_51_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrepeater60 repeater61/X VGND VGND VPWR VPWR repeater60/X sky130_fd_sc_hd__clkbuf_2
Xrepeater71 repeater72/X VGND VGND VPWR VPWR repeater71/X sky130_fd_sc_hd__clkbuf_2
X_1606_ _1626_/CLK _1606_/D repeater71/X VGND VGND VPWR VPWR _1606_/Q sky130_fd_sc_hd__dfrtp_1
X_0985_ _1360_/A _0985_/B VGND VGND VPWR VPWR _1366_/B sky130_fd_sc_hd__nor2_1
X_1537_ _1576_/CLK _1537_/D repeater61/X VGND VGND VPWR VPWR _1537_/Q sky130_fd_sc_hd__dfrtp_1
X_1399_ _0783_/A _0783_/B _1415_/C _1611_/Q VGND VGND VPWR VPWR _1399_/X sky130_fd_sc_hd__a31o_1
X_1468_ _1618_/CLK _1468_/D VGND VGND VPWR VPWR _1468_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_27_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0770_ _1505_/Q _0752_/A VGND VGND VPWR VPWR _0943_/D sky130_fd_sc_hd__or2b_1
XFILLER_56_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1322_ _1212_/X _1573_/Q _1333_/S VGND VGND VPWR VPWR _1323_/A sky130_fd_sc_hd__mux2_1
X_1253_ _1574_/Q _1577_/Q _1576_/Q _1253_/D VGND VGND VPWR VPWR _1255_/C sky130_fd_sc_hd__and4bb_1
X_1184_ _0915_/Y _1183_/Y _1210_/C VGND VGND VPWR VPWR _1524_/D sky130_fd_sc_hd__o21ai_1
XFILLER_32_283 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_0968_ _0968_/A _1033_/B _1537_/Q _1535_/Q VGND VGND VPWR VPWR _0968_/Y sky130_fd_sc_hd__nor4b_1
X_0899_ _0918_/C _1343_/S _0899_/C _1546_/Q VGND VGND VPWR VPWR _0899_/Y sky130_fd_sc_hd__nand4_1
XFILLER_59_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_180 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_94 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0822_ _0822_/A _0822_/B VGND VGND VPWR VPWR _0918_/C sky130_fd_sc_hd__or2_2
XFILLER_9_44 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0753_ _0753_/A _1509_/Q VGND VGND VPWR VPWR _0941_/A sky130_fd_sc_hd__or2b_1
XFILLER_50_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1236_ _1269_/B _1567_/Q VGND VGND VPWR VPWR _1236_/X sky130_fd_sc_hd__and2b_1
X_1305_ _0918_/C _0938_/X _1565_/Q VGND VGND VPWR VPWR _1305_/Y sky130_fd_sc_hd__a21oi_1
X_1167_ _1165_/Y _1166_/X _1157_/X _1158_/X _1210_/C VGND VGND VPWR VPWR _1519_/D
+ sky130_fd_sc_hd__o221a_1
X_1098_ _1488_/Q _1506_/Q _1108_/S VGND VGND VPWR VPWR _1099_/A sky130_fd_sc_hd__mux2_1
XFILLER_12_209 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1021_ _1458_/Q _1020_/X _1021_/S VGND VGND VPWR VPWR _1022_/A sky130_fd_sc_hd__mux2_1
X_0805_ _1580_/Q _1583_/Q _1584_/Q VGND VGND VPWR VPWR _0822_/B sky130_fd_sc_hd__nand3_2
X_0736_ _1537_/Q VGND VGND VPWR VPWR _1032_/B sky130_fd_sc_hd__clkbuf_2
X_1219_ _0843_/X _0857_/X _0860_/X _1218_/Y VGND VGND VPWR VPWR _1536_/D sky130_fd_sc_hd__o31ai_1
XFILLER_52_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_183 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1570_ _1577_/CLK _1570_/D VGND VGND VPWR VPWR _1570_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1004_ _1450_/Q _1449_/Q _1012_/S VGND VGND VPWR VPWR _1005_/A sky130_fd_sc_hd__mux2_1
XFILLER_22_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0719_ _1603_/Q _1602_/Q _1610_/Q VGND VGND VPWR VPWR _0721_/C sky130_fd_sc_hd__a21o_1
XFILLER_13_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_120 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_156 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput31 _1464_/Q VGND VGND VPWR VPWR data_strobe sky130_fd_sc_hd__buf_2
Xoutput42 _0935_/X VGND VGND VPWR VPWR tx_se0 sky130_fd_sc_hd__buf_2
XFILLER_48_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1622_ _1625_/CLK _1622_/D repeater56/X VGND VGND VPWR VPWR _1622_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_31_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_212 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1553_ _1578_/CLK _1553_/D repeater46/X VGND VGND VPWR VPWR _1553_/Q sky130_fd_sc_hd__dfstp_1
X_1484_ _1626_/CLK _1484_/D repeater72/X VGND VGND VPWR VPWR _1484_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_10_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrepeater61 repeater69/X VGND VGND VPWR VPWR repeater61/X sky130_fd_sc_hd__clkbuf_2
Xrepeater50 _0932_/X VGND VGND VPWR VPWR repeater50/X sky130_fd_sc_hd__clkbuf_2
X_0984_ _1610_/Q _1458_/Q _0983_/Y VGND VGND VPWR VPWR _1020_/B sky130_fd_sc_hd__o21a_1
Xrepeater72 repeater73/X VGND VGND VPWR VPWR repeater72/X sky130_fd_sc_hd__clkbuf_2
X_1536_ _1597_/CLK _1536_/D repeater69/X VGND VGND VPWR VPWR _1536_/Q sky130_fd_sc_hd__dfrtp_1
X_1605_ _1626_/CLK _1605_/D repeater71/X VGND VGND VPWR VPWR _1605_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_59_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1467_ _1532_/CLK _1467_/D repeater66/X VGND VGND VPWR VPWR _1467_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_27_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1398_ _1398_/A VGND VGND VPWR VPWR _1398_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_35_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_262 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_152 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1321_ _1321_/A VGND VGND VPWR VPWR _1572_/D sky130_fd_sc_hd__clkbuf_1
X_1252_ _1252_/A _1252_/B _1575_/Q VGND VGND VPWR VPWR _1255_/B sky130_fd_sc_hd__and3_1
X_1183_ _1524_/Q _1183_/B VGND VGND VPWR VPWR _1183_/Y sky130_fd_sc_hd__xnor2_1
XFILLER_24_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_295 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_0967_ _0967_/A _0967_/B VGND VGND VPWR VPWR _1482_/D sky130_fd_sc_hd__nand2_1
XFILLER_59_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1519_ _1625_/CLK _1519_/D repeater62/X VGND VGND VPWR VPWR _1519_/Q sky130_fd_sc_hd__dfrtp_1
X_0898_ _1429_/S VGND VGND VPWR VPWR _1343_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_23_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0752_ _0752_/A _1505_/Q VGND VGND VPWR VPWR _0942_/A sky130_fd_sc_hd__or2b_1
X_0821_ _1222_/A VGND VGND VPWR VPWR _0918_/B sky130_fd_sc_hd__clkbuf_2
XFILLER_14_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1166_ _1518_/Q _1517_/Q _1152_/X _1168_/B VGND VGND VPWR VPWR _1166_/X sky130_fd_sc_hd__o31a_1
XFILLER_49_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1235_ _1235_/A VGND VGND VPWR VPWR _1542_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_37_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1304_ _1260_/B _1260_/C _1564_/Q VGND VGND VPWR VPWR _1304_/X sky130_fd_sc_hd__a21bo_1
X_1097_ _1144_/S VGND VGND VPWR VPWR _1108_/S sky130_fd_sc_hd__buf_2
XFILLER_20_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_61 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1020_ _1457_/Q _1020_/B VGND VGND VPWR VPWR _1020_/X sky130_fd_sc_hd__xor2_1
XFILLER_15_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0804_ _1586_/Q _1585_/Q _1582_/Q _1581_/Q VGND VGND VPWR VPWR _0822_/A sky130_fd_sc_hd__nand4b_4
XFILLER_6_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0735_ _0879_/A _1435_/Q VGND VGND VPWR VPWR _0735_/X sky130_fd_sc_hd__and2_1
XFILLER_52_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1149_ _1149_/A VGND VGND VPWR VPWR _1150_/B sky130_fd_sc_hd__clkbuf_2
XFILLER_37_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1218_ _0857_/A _0860_/A _1033_/B VGND VGND VPWR VPWR _1218_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_25_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1003_ _1003_/A VGND VGND VPWR VPWR _1449_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_19_195 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0718_ _1603_/Q _0922_/C _1458_/Q VGND VGND VPWR VPWR _0721_/B sky130_fd_sc_hd__nand3_1
XFILLER_13_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_168 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput43 _0915_/Y VGND VGND VPWR VPWR usb_rst sky130_fd_sc_hd__buf_2
Xoutput32 _1463_/Q VGND VGND VPWR VPWR direction_in sky130_fd_sc_hd__buf_2
XFILLER_0_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_213 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1621_ _1624_/CLK _1621_/D repeater56/X VGND VGND VPWR VPWR _1621_/Q sky130_fd_sc_hd__dfrtp_1
X_1552_ _1578_/CLK _1552_/D repeater46/X VGND VGND VPWR VPWR _1552_/Q sky130_fd_sc_hd__dfstp_1
XTAP_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1483_ _1597_/CLK _1483_/D repeater74/X VGND VGND VPWR VPWR _1483_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_9_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater62 repeater63/X VGND VGND VPWR VPWR repeater62/X sky130_fd_sc_hd__clkbuf_2
X_0983_ _0929_/A _0922_/C _1610_/Q _1458_/Q VGND VGND VPWR VPWR _0983_/Y sky130_fd_sc_hd__a22oi_1
Xrepeater73 repeater74/X VGND VGND VPWR VPWR repeater73/X sky130_fd_sc_hd__clkbuf_1
Xrepeater51 hold2/A VGND VGND VPWR VPWR _0838_/A sky130_fd_sc_hd__buf_2
X_1535_ _1587_/CLK _1535_/D repeater60/X VGND VGND VPWR VPWR _1535_/Q sky130_fd_sc_hd__dfrtp_1
X_1604_ _1626_/CLK _1604_/D _0932_/B1 VGND VGND VPWR VPWR _1604_/Q sky130_fd_sc_hd__dfrtp_1
X_1397_ _1397_/A _1605_/Q _1397_/C VGND VGND VPWR VPWR _1398_/A sky130_fd_sc_hd__or3_1
X_1466_ _1597_/CLK _1466_/D repeater74/X VGND VGND VPWR VPWR _1466_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_50_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_205 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_238 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1320_ _1215_/X _1572_/Q _1320_/S VGND VGND VPWR VPWR _1321_/A sky130_fd_sc_hd__mux2_1
XFILLER_5_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_341 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1182_ _1523_/Q _1182_/B VGND VGND VPWR VPWR _1183_/B sky130_fd_sc_hd__nor2_1
X_1251_ _0846_/Y _0839_/Y _1250_/Y _0847_/Y VGND VGND VPWR VPWR _1252_/B sky130_fd_sc_hd__o211ai_1
X_0966_ _0963_/B _0963_/C _0963_/D _0903_/C VGND VGND VPWR VPWR _0967_/B sky130_fd_sc_hd__a31o_1
X_0897_ _0875_/X _0897_/B _0897_/C VGND VGND VPWR VPWR _1437_/D sky130_fd_sc_hd__nand3b_1
X_1518_ _1625_/CLK _1518_/D repeater64/X VGND VGND VPWR VPWR _1518_/Q sky130_fd_sc_hd__dfrtp_2
X_1449_ _1559_/CLK _1449_/D repeater48/X VGND VGND VPWR VPWR _1449_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_55_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_55_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_252 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0820_ _0832_/A _0832_/B _0813_/X _0814_/Y VGND VGND VPWR VPWR _1222_/A sky130_fd_sc_hd__o22ai_4
X_0751_ _0972_/B _1033_/B _1032_/B _0968_/A VGND VGND VPWR VPWR _0774_/A sky130_fd_sc_hd__and4bb_1
XFILLER_14_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_11_0_clk_48 clkbuf_0_clk_48/X VGND VGND VPWR VPWR _1532_/CLK sky130_fd_sc_hd__clkbuf_8
X_1303_ _1303_/A VGND VGND VPWR VPWR _1564_/D sky130_fd_sc_hd__clkbuf_1
X_1165_ _1168_/B _1168_/C VGND VGND VPWR VPWR _1165_/Y sky130_fd_sc_hd__nor2_1
X_1234_ _1233_/X _1542_/Q _1234_/S VGND VGND VPWR VPWR _1235_/A sky130_fd_sc_hd__mux2_1
X_1096_ _1096_/A VGND VGND VPWR VPWR _1487_/D sky130_fd_sc_hd__clkbuf_1
Xclkbuf_0_clk_48 clk_48 VGND VGND VPWR VPWR clkbuf_0_clk_48/X sky130_fd_sc_hd__clkbuf_16
XFILLER_20_200 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_0949_ _1439_/Q _1037_/B _0948_/Y _1440_/Q VGND VGND VPWR VPWR _0950_/A sky130_fd_sc_hd__a31oi_1
XFILLER_47_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_88 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0803_ _0879_/A _1512_/Q _0859_/C VGND VGND VPWR VPWR _0803_/X sky130_fd_sc_hd__or3_1
X_0734_ _1222_/C VGND VGND VPWR VPWR _0879_/A sky130_fd_sc_hd__clkbuf_2
X_1148_ _1533_/Q _1158_/A _1357_/C VGND VGND VPWR VPWR _1149_/A sky130_fd_sc_hd__o21ai_1
X_1217_ _1215_/X _0857_/X _0860_/X _1216_/Y VGND VGND VPWR VPWR _1535_/D sky130_fd_sc_hd__o31a_1
X_1079_ input6/X _1071_/X _1086_/A _1073_/B _1473_/Q VGND VGND VPWR VPWR _1473_/D
+ sky130_fd_sc_hd__a32o_1
XFILLER_20_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1002_ _1449_/Q _1448_/Q _1012_/S VGND VGND VPWR VPWR _1003_/A sky130_fd_sc_hd__mux2_1
XFILLER_19_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0717_ _1602_/Q VGND VGND VPWR VPWR _0922_/C sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_15_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_89 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput33 _1459_/Q VGND VGND VPWR VPWR endpoint[0] sky130_fd_sc_hd__buf_2
XFILLER_0_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_56_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1620_ _1624_/CLK _1620_/D repeater56/X VGND VGND VPWR VPWR _1620_/Q sky130_fd_sc_hd__dfrtp_1
X_1482_ _1487_/CLK _1482_/D repeater73/X VGND VGND VPWR VPWR _1482_/Q sky130_fd_sc_hd__dfrtp_1
X_1551_ _1578_/CLK _1551_/D repeater46/X VGND VGND VPWR VPWR _1551_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_54_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_45_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_32 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_291 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xrepeater52 repeater53/X VGND VGND VPWR VPWR repeater52/X sky130_fd_sc_hd__clkbuf_2
Xrepeater63 _1053_/B1 VGND VGND VPWR VPWR repeater63/X sky130_fd_sc_hd__clkbuf_2
X_0982_ _1069_/C _0978_/Y _0981_/X VGND VGND VPWR VPWR _1434_/D sky130_fd_sc_hd__o21a_1
XFILLER_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xrepeater74 repeater75/X VGND VGND VPWR VPWR repeater74/X sky130_fd_sc_hd__clkbuf_2
XFILLER_12_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1534_ _1576_/CLK _1534_/D repeater60/X VGND VGND VPWR VPWR _1534_/Q sky130_fd_sc_hd__dfrtp_1
X_1603_ _1618_/CLK _1603_/D _0932_/B1 VGND VGND VPWR VPWR _1603_/Q sky130_fd_sc_hd__dfrtp_2
X_1465_ _1559_/CLK _1465_/D input13/X VGND VGND VPWR VPWR _1465_/Q sky130_fd_sc_hd__dfrtp_1
X_1396_ _1484_/Q _1393_/X _1395_/X _1609_/Q VGND VGND VPWR VPWR _1609_/D sky130_fd_sc_hd__a22o_1
XFILLER_10_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_9_0_clk_48 clkbuf_0_clk_48/X VGND VGND VPWR VPWR _1442_/CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_5_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1181_ _1181_/A _1181_/B _1181_/C _1195_/D VGND VGND VPWR VPWR _1182_/B sky130_fd_sc_hd__nand4_1
X_1250_ _1578_/Q VGND VGND VPWR VPWR _1250_/Y sky130_fd_sc_hd__inv_2
X_0965_ _0967_/A _0965_/B VGND VGND VPWR VPWR _1481_/D sky130_fd_sc_hd__nand2_1
X_0896_ _1037_/A _0899_/C _1095_/S _0889_/X _0895_/Y VGND VGND VPWR VPWR _0897_/C
+ sky130_fd_sc_hd__a32oi_1
X_1517_ _1625_/CLK _1517_/D repeater64/X VGND VGND VPWR VPWR _1517_/Q sky130_fd_sc_hd__dfrtp_1
X_1448_ _1559_/CLK _1448_/D repeater48/X VGND VGND VPWR VPWR _1448_/Q sky130_fd_sc_hd__dfstp_1
X_1379_ _1378_/X _0879_/B _1605_/Q _1397_/A VGND VGND VPWR VPWR _1389_/A sky130_fd_sc_hd__a211o_1
XFILLER_23_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_231 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0750_ _1534_/Q VGND VGND VPWR VPWR _0968_/A sky130_fd_sc_hd__clkbuf_2
X_1233_ _1269_/B _1568_/Q VGND VGND VPWR VPWR _1233_/X sky130_fd_sc_hd__and2b_1
XFILLER_29_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1302_ _1563_/Q _1564_/Q _1307_/S VGND VGND VPWR VPWR _1303_/A sky130_fd_sc_hd__mux2_1
X_1164_ _1164_/A _1164_/B _1518_/Q _1517_/Q VGND VGND VPWR VPWR _1168_/C sky130_fd_sc_hd__or4_2
X_1095_ _1487_/Q _1505_/Q _1095_/S VGND VGND VPWR VPWR _1096_/A sky130_fd_sc_hd__mux2_1
XFILLER_20_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0948_ _1222_/C _0948_/B VGND VGND VPWR VPWR _0948_/Y sky130_fd_sc_hd__nor2_1
X_0879_ _0879_/A _0879_/B VGND VGND VPWR VPWR _0879_/Y sky130_fd_sc_hd__nor2_1
XFILLER_55_142 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0802_ _1513_/Q VGND VGND VPWR VPWR _0859_/C sky130_fd_sc_hd__clkbuf_2
X_0733_ _1514_/Q VGND VGND VPWR VPWR _1222_/C sky130_fd_sc_hd__buf_2
XFILLER_37_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1216_ _0857_/A _0860_/A _0972_/B VGND VGND VPWR VPWR _1216_/Y sky130_fd_sc_hd__o21bai_1
XFILLER_37_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1147_ _1208_/B _1208_/C _1208_/D VGND VGND VPWR VPWR _1158_/A sky130_fd_sc_hd__nand3_1
X_1078_ _1078_/A _1078_/B VGND VGND VPWR VPWR _1086_/A sky130_fd_sc_hd__nor2_1
XFILLER_45_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1001_ _1021_/S VGND VGND VPWR VPWR _1012_/S sky130_fd_sc_hd__clkbuf_2
X_0716_ _1606_/Q _1607_/Q _1608_/Q VGND VGND VPWR VPWR _0934_/B sky130_fd_sc_hd__nand3b_4
XFILLER_40_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput34 _1460_/Q VGND VGND VPWR VPWR endpoint[1] sky130_fd_sc_hd__buf_2
XFILLER_31_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput23 _1485_/Q VGND VGND VPWR VPWR data_out[0] sky130_fd_sc_hd__buf_2
XFILLER_0_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_64 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1481_ _1487_/CLK _1481_/D repeater73/X VGND VGND VPWR VPWR _1481_/Q sky130_fd_sc_hd__dfrtp_1
X_1550_ _1597_/CLK _1550_/D repeater46/X VGND VGND VPWR VPWR _1550_/Q sky130_fd_sc_hd__dfstp_1
XTAP_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_251 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_44 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_3_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrepeater53 _0927_/B VGND VGND VPWR VPWR repeater53/X sky130_fd_sc_hd__clkbuf_2
X_0981_ _0732_/X _0778_/X _0889_/X _0977_/X _1084_/B VGND VGND VPWR VPWR _0981_/X
+ sky130_fd_sc_hd__a311o_1
Xrepeater64 repeater65/X VGND VGND VPWR VPWR repeater64/X sky130_fd_sc_hd__clkbuf_2
X_1602_ _1618_/CLK _1602_/D _0932_/B1 VGND VGND VPWR VPWR _1602_/Q sky130_fd_sc_hd__dfrtp_1
Xrepeater75 input13/X VGND VGND VPWR VPWR repeater75/X sky130_fd_sc_hd__clkbuf_2
XFILLER_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1533_ _1600_/CLK _1533_/D repeater63/X VGND VGND VPWR VPWR _1533_/Q sky130_fd_sc_hd__dfrtp_1
X_1464_ _1532_/CLK _1464_/D repeater65/X VGND VGND VPWR VPWR _1464_/Q sky130_fd_sc_hd__dfrtp_1
X_1395_ _0879_/B _1366_/A _1397_/A _1605_/Q _1397_/C VGND VGND VPWR VPWR _1395_/X
+ sky130_fd_sc_hd__a2111o_1
XFILLER_50_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1180_ _0915_/A _1178_/X _1179_/Y _0918_/B VGND VGND VPWR VPWR _1523_/D sky130_fd_sc_hd__a31o_1
X_0964_ _1481_/Q _0730_/Y _0963_/X VGND VGND VPWR VPWR _0965_/B sky130_fd_sc_hd__a21oi_1
X_1516_ _1625_/CLK _1516_/D repeater62/X VGND VGND VPWR VPWR _1516_/Q sky130_fd_sc_hd__dfrtp_1
X_0895_ _0895_/A _0895_/B VGND VGND VPWR VPWR _0895_/Y sky130_fd_sc_hd__nand2_1
X_1378_ _0929_/A _0985_/B _0934_/B _0721_/B _0721_/C VGND VGND VPWR VPWR _1378_/X
+ sky130_fd_sc_hd__o2111a_1
X_1447_ _1559_/CLK _1447_/D repeater48/X VGND VGND VPWR VPWR _1447_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_23_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_32 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1232_ _1232_/A VGND VGND VPWR VPWR _1541_/D sky130_fd_sc_hd__clkbuf_1
X_1301_ _1301_/A VGND VGND VPWR VPWR _1563_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_52_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1163_ _1519_/Q VGND VGND VPWR VPWR _1168_/B sky130_fd_sc_hd__dlymetal6s2s_1
X_1094_ _1094_/A VGND VGND VPWR VPWR _1486_/D sky130_fd_sc_hd__clkbuf_1
X_0947_ _0947_/A _0947_/B _0947_/C _0947_/D VGND VGND VPWR VPWR _1037_/B sky130_fd_sc_hd__nor4_2
X_0878_ _0879_/A _1438_/Q _1437_/Q VGND VGND VPWR VPWR _0878_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_55_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_176 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0801_ _0794_/X _1084_/A _0742_/Y _0800_/X VGND VGND VPWR VPWR _1441_/D sky130_fd_sc_hd__a31o_1
XFILLER_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0732_ _1482_/Q _1481_/Q _0730_/Y _0895_/B VGND VGND VPWR VPWR _0732_/X sky130_fd_sc_hd__o31a_1
X_1146_ _1515_/Q VGND VGND VPWR VPWR _1164_/A sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_37_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1215_ _1269_/B _1571_/Q VGND VGND VPWR VPWR _1215_/X sky130_fd_sc_hd__and2b_1
XFILLER_1_60 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1077_ _1075_/X _1084_/C _1472_/Q _1076_/X VGND VGND VPWR VPWR _1472_/D sky130_fd_sc_hd__a22o_1
XFILLER_29_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_23 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_110 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1000_ _1000_/A VGND VGND VPWR VPWR _1448_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_19_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0715_ _0985_/B VGND VGND VPWR VPWR _1373_/A sky130_fd_sc_hd__clkbuf_2
X_1129_ _1501_/Q _1127_/Y _0862_/X _1128_/X VGND VGND VPWR VPWR _1502_/D sky130_fd_sc_hd__o211a_1
XFILLER_25_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput35 _1461_/Q VGND VGND VPWR VPWR endpoint[2] sky130_fd_sc_hd__buf_2
Xoutput24 _1486_/Q VGND VGND VPWR VPWR data_out[1] sky130_fd_sc_hd__buf_2
XFILLER_0_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_341 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1480_ _1487_/CLK _1480_/D repeater74/X VGND VGND VPWR VPWR _1480_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_53_263 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_260 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater65 repeater66/X VGND VGND VPWR VPWR repeater65/X sky130_fd_sc_hd__clkbuf_2
Xrepeater54 input13/X VGND VGND VPWR VPWR _0927_/B sky130_fd_sc_hd__clkbuf_2
X_0980_ _0874_/B _0978_/Y _0979_/X VGND VGND VPWR VPWR _1433_/D sky130_fd_sc_hd__o21a_1
X_1532_ _1532_/CLK _1532_/D repeater66/X VGND VGND VPWR VPWR _1532_/Q sky130_fd_sc_hd__dfrtp_1
X_1601_ _1618_/CLK _1601_/D _0932_/B1 VGND VGND VPWR VPWR _1601_/Q sky130_fd_sc_hd__dfrtp_2
X_1394_ _1394_/A _1394_/B VGND VGND VPWR VPWR _1397_/C sky130_fd_sc_hd__nor2_1
X_1463_ _1597_/CLK _1463_/D repeater69/X VGND VGND VPWR VPWR _1463_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_50_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_48 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_252 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0894_ _0963_/B _0963_/C _0903_/C _0963_/D VGND VGND VPWR VPWR _0895_/A sky130_fd_sc_hd__nand4_1
X_0963_ _1482_/Q _0963_/B _0963_/C _0963_/D VGND VGND VPWR VPWR _0963_/X sky130_fd_sc_hd__and4_1
X_1515_ _1625_/CLK _1515_/D repeater62/X VGND VGND VPWR VPWR _1515_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_55_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1377_ _1377_/A VGND VGND VPWR VPWR _1603_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_4_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1446_ _1559_/CLK _1446_/D repeater50/X VGND VGND VPWR VPWR _1446_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_23_211 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_44 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1162_ _1175_/A _1161_/X _1157_/X _1158_/X _1210_/C VGND VGND VPWR VPWR _1518_/D
+ sky130_fd_sc_hd__o221a_1
X_1231_ _0836_/X _1541_/Q _1234_/S VGND VGND VPWR VPWR _1232_/A sky130_fd_sc_hd__mux2_1
X_1300_ _1562_/Q _1563_/Q _1307_/S VGND VGND VPWR VPWR _1301_/A sky130_fd_sc_hd__mux2_1
X_1093_ _1486_/Q _1504_/Q _1095_/S VGND VGND VPWR VPWR _1094_/A sky130_fd_sc_hd__mux2_1
X_0946_ _0944_/X _0945_/Y _1502_/Q _1547_/Q _0761_/C VGND VGND VPWR VPWR _0947_/D
+ sky130_fd_sc_hd__o2111ai_1
XFILLER_9_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0877_ _1041_/C VGND VGND VPWR VPWR _1060_/A sky130_fd_sc_hd__clkbuf_2
X_1429_ _1625_/Q _1624_/Q _1429_/S VGND VGND VPWR VPWR _1430_/A sky130_fd_sc_hd__mux2_1
XFILLER_18_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_89 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0800_ _1069_/C _0973_/A _0977_/D _0798_/X _0970_/C VGND VGND VPWR VPWR _0800_/X
+ sky130_fd_sc_hd__a32o_1
X_0731_ _1536_/Q _1535_/Q _1534_/Q VGND VGND VPWR VPWR _0895_/B sky130_fd_sc_hd__and3b_1
XFILLER_34_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1145_ _1145_/A VGND VGND VPWR VPWR _1510_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_37_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1214_ _1212_/X _0857_/X _0860_/X _1213_/Y VGND VGND VPWR VPWR _1534_/D sky130_fd_sc_hd__o31a_1
XFILLER_1_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1076_ _1049_/X _1052_/X _1080_/A VGND VGND VPWR VPWR _1076_/X sky130_fd_sc_hd__a21o_1
X_0929_ _0929_/A VGND VGND VPWR VPWR _0929_/X sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_20_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_48 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_339 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_180 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0714_ _1602_/Q VGND VGND VPWR VPWR _0985_/B sky130_fd_sc_hd__inv_2
XFILLER_57_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_117 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1128_ _0918_/C _1343_/S _1546_/Q _1502_/Q VGND VGND VPWR VPWR _1128_/X sky130_fd_sc_hd__a31o_1
X_1059_ _1468_/Q _1057_/Y _1058_/X _1080_/A VGND VGND VPWR VPWR _1468_/D sky130_fd_sc_hd__o22a_1
XFILLER_25_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput36 _1462_/Q VGND VGND VPWR VPWR endpoint[3] sky130_fd_sc_hd__buf_2
Xoutput25 _1487_/Q VGND VGND VPWR VPWR data_out[2] sky130_fd_sc_hd__buf_2
XFILLER_0_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrepeater55 repeater57/X VGND VGND VPWR VPWR repeater55/X sky130_fd_sc_hd__clkbuf_2
Xrepeater66 _1053_/B1 VGND VGND VPWR VPWR repeater66/X sky130_fd_sc_hd__clkbuf_2
Xrepeater44 repeater45/X VGND VGND VPWR VPWR repeater44/X sky130_fd_sc_hd__clkbuf_2
X_1462_ _1545_/CLK _1462_/D repeater52/X VGND VGND VPWR VPWR _1462_/Q sky130_fd_sc_hd__dfrtp_1
X_1600_ _1600_/CLK _1600_/D VGND VGND VPWR VPWR _1600_/Q sky130_fd_sc_hd__dfxtp_1
X_1531_ _1600_/CLK _1531_/D repeater66/X VGND VGND VPWR VPWR _1531_/Q sky130_fd_sc_hd__dfrtp_1
Xclkbuf_4_14_0_clk_48 clkbuf_0_clk_48/X VGND VGND VPWR VPWR _1600_/CLK sky130_fd_sc_hd__clkbuf_8
X_1393_ _1393_/A VGND VGND VPWR VPWR _1393_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_35_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_301 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_297 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_0962_ _0730_/Y _0960_/Y _0961_/X _0950_/A VGND VGND VPWR VPWR _1480_/D sky130_fd_sc_hd__o211ai_1
X_0893_ _1481_/Q VGND VGND VPWR VPWR _0963_/D sky130_fd_sc_hd__inv_2
X_1514_ _1587_/CLK _1514_/D repeater60/X VGND VGND VPWR VPWR _1514_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_4_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1445_ _1487_/CLK _1445_/D repeater50/X VGND VGND VPWR VPWR _1445_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_55_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1376_ _1375_/X _0929_/X _1376_/S VGND VGND VPWR VPWR _1377_/A sky130_fd_sc_hd__mux2_1
XFILLER_23_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1161_ _1164_/A _1164_/B _1517_/Q _1518_/Q VGND VGND VPWR VPWR _1161_/X sky130_fd_sc_hd__o31a_1
X_1230_ _1230_/A VGND VGND VPWR VPWR _1540_/D sky130_fd_sc_hd__clkbuf_1
X_1092_ _1092_/A VGND VGND VPWR VPWR _1485_/D sky130_fd_sc_hd__clkbuf_1
X_0945_ _0945_/A _1504_/Q VGND VGND VPWR VPWR _0945_/Y sky130_fd_sc_hd__nor2_1
X_0876_ _1442_/Q _1441_/Q VGND VGND VPWR VPWR _1041_/C sky130_fd_sc_hd__nor2_2
X_1428_ _1624_/Q _0938_/X _0819_/C VGND VGND VPWR VPWR _1624_/D sky130_fd_sc_hd__o21ba_1
XFILLER_28_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1359_ _1069_/A _1069_/D _1357_/B _1357_/A _1159_/A VGND VGND VPWR VPWR _1600_/D
+ sky130_fd_sc_hd__a2111o_1
XFILLER_28_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0730_ _0730_/A _0730_/B _0730_/C VGND VGND VPWR VPWR _0730_/Y sky130_fd_sc_hd__nand3_1
XFILLER_24_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1213_ _0857_/X _0860_/X _0972_/C VGND VGND VPWR VPWR _1213_/Y sky130_fd_sc_hd__o21bai_1
XFILLER_27_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_2_0_clk_48 clkbuf_0_clk_48/X VGND VGND VPWR VPWR _1487_/CLK sky130_fd_sc_hd__clkbuf_8
X_1144_ _1510_/Q _1500_/Q _1144_/S VGND VGND VPWR VPWR _1145_/A sky130_fd_sc_hd__mux2_1
XFILLER_37_156 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_95 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1075_ _0973_/B input5/X _0973_/C _1078_/A VGND VGND VPWR VPWR _1075_/X sky130_fd_sc_hd__a31o_1
X_0859_ _1222_/A _1222_/B _0859_/C _1222_/D VGND VGND VPWR VPWR _0860_/A sky130_fd_sc_hd__nand4_2
X_0928_ _0928_/A VGND VGND VPWR VPWR _0928_/X sky130_fd_sc_hd__buf_6
XFILLER_20_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0713_ _1601_/Q VGND VGND VPWR VPWR _1370_/B sky130_fd_sc_hd__inv_2
XFILLER_57_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1127_ _1546_/Q _1127_/B VGND VGND VPWR VPWR _1127_/Y sky130_fd_sc_hd__nand2_1
X_1058_ input1/X _1052_/X _1060_/A VGND VGND VPWR VPWR _1058_/X sky130_fd_sc_hd__o21a_1
XFILLER_21_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_26 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput26 _1488_/Q VGND VGND VPWR VPWR data_out[3] sky130_fd_sc_hd__buf_2
XFILLER_0_203 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput37 _1483_/Q VGND VGND VPWR VPWR setup sky130_fd_sc_hd__buf_2
XFILLER_48_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_44_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_232 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xrepeater56 repeater57/X VGND VGND VPWR VPWR repeater56/X sky130_fd_sc_hd__clkbuf_2
XFILLER_32_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrepeater67 repeater68/X VGND VGND VPWR VPWR _1053_/B1 sky130_fd_sc_hd__clkbuf_2
Xrepeater45 repeater47/X VGND VGND VPWR VPWR repeater45/X sky130_fd_sc_hd__clkbuf_2
XFILLER_8_155 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1530_ _1600_/CLK _1530_/D repeater65/X VGND VGND VPWR VPWR _1530_/Q sky130_fd_sc_hd__dfrtp_1
X_1461_ _1577_/CLK _1461_/D input13/X VGND VGND VPWR VPWR _1461_/Q sky130_fd_sc_hd__dfrtp_1
X_1392_ _1415_/B _1415_/C _1392_/C VGND VGND VPWR VPWR _1393_/A sky130_fd_sc_hd__and3_1
XFILLER_2_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_313 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_224 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_0961_ _0730_/A _0730_/B _0730_/C VGND VGND VPWR VPWR _0961_/X sky130_fd_sc_hd__a21o_1
X_0892_ _1482_/Q VGND VGND VPWR VPWR _0903_/C sky130_fd_sc_hd__inv_2
X_1513_ _1587_/CLK _1513_/D repeater59/X VGND VGND VPWR VPWR _1513_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_4_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1444_ _1487_/CLK _1444_/D repeater50/X VGND VGND VPWR VPWR _1444_/Q sky130_fd_sc_hd__dfstp_1
X_1375_ _1370_/A _1370_/B _0931_/A _1374_/X VGND VGND VPWR VPWR _1375_/X sky130_fd_sc_hd__a31o_1
XFILLER_55_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1160_ _1181_/A _1156_/X _1157_/X _1158_/X _1210_/C VGND VGND VPWR VPWR _1517_/D
+ sky130_fd_sc_hd__o221a_1
XFILLER_49_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1091_ _1485_/Q _1503_/Q _1095_/S VGND VGND VPWR VPWR _1092_/A sky130_fd_sc_hd__mux2_1
X_0944_ _0945_/A _1504_/Q VGND VGND VPWR VPWR _0944_/X sky130_fd_sc_hd__and2_1
XFILLER_20_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0875_ _0973_/B _0874_/Y _0973_/C _0973_/A VGND VGND VPWR VPWR _0875_/X sky130_fd_sc_hd__and4bb_1
X_1427_ _1427_/A VGND VGND VPWR VPWR _1623_/D sky130_fd_sc_hd__clkbuf_1
X_1358_ _1358_/A VGND VGND VPWR VPWR _1599_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_28_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_38 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_48 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1289_ _1557_/Q _1558_/Q _1291_/S VGND VGND VPWR VPWR _1290_/A sky130_fd_sc_hd__mux2_1
XFILLER_42_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1212_ _1239_/A _1572_/Q VGND VGND VPWR VPWR _1212_/X sky130_fd_sc_hd__and2b_1
X_1143_ _1143_/A VGND VGND VPWR VPWR _1509_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_33_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1074_ _1080_/A _1068_/Y _1072_/Y _1060_/Y _1073_/Y VGND VGND VPWR VPWR _1471_/D
+ sky130_fd_sc_hd__o221ai_1
X_0927_ _1357_/A _0927_/B VGND VGND VPWR VPWR _0928_/A sky130_fd_sc_hd__and2_1
X_0858_ _1239_/A _1573_/Q VGND VGND VPWR VPWR _1222_/B sky130_fd_sc_hd__and2b_1
XFILLER_29_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0789_ _0742_/Y _0778_/X _0788_/X VGND VGND VPWR VPWR _0789_/X sky130_fd_sc_hd__a21bo_1
XFILLER_43_138 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1126_ _1501_/Q _0862_/X _1095_/S VGND VGND VPWR VPWR _1501_/D sky130_fd_sc_hd__a21o_1
X_1057_ _1049_/X _1052_/X _1080_/A VGND VGND VPWR VPWR _1057_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_31_38 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput27 _1489_/Q VGND VGND VPWR VPWR data_out[4] sky130_fd_sc_hd__buf_2
Xoutput38 _1465_/Q VGND VGND VPWR VPWR success sky130_fd_sc_hd__buf_2
XFILLER_0_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1109_ _1109_/A VGND VGND VPWR VPWR _1493_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_26_38 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrepeater57 repeater58/X VGND VGND VPWR VPWR repeater57/X sky130_fd_sc_hd__clkbuf_2
Xrepeater46 repeater47/X VGND VGND VPWR VPWR repeater46/X sky130_fd_sc_hd__clkbuf_2
XFILLER_8_101 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_167 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrepeater68 repeater69/X VGND VGND VPWR VPWR repeater68/X sky130_fd_sc_hd__clkbuf_2
XFILLER_59_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1460_ _1569_/CLK _1460_/D repeater52/X VGND VGND VPWR VPWR _1460_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_4_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1391_ _1603_/Q _1601_/Q _0922_/C _0740_/A _0934_/B VGND VGND VPWR VPWR _1392_/C
+ sky130_fd_sc_hd__o311a_1
XTAP_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1589_ _1600_/CLK _1589_/D repeater59/X VGND VGND VPWR VPWR _1589_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_37_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_280 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_236 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0960_ _1482_/Q _1481_/Q VGND VGND VPWR VPWR _0960_/Y sky130_fd_sc_hd__nor2_1
X_1512_ _1576_/CLK _1512_/D repeater59/X VGND VGND VPWR VPWR _1512_/Q sky130_fd_sc_hd__dfrtp_1
X_0891_ _1479_/Q _1480_/Q VGND VGND VPWR VPWR _0963_/C sky130_fd_sc_hd__nor2_1
XFILLER_4_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1443_ _1487_/CLK _1443_/D _0932_/X VGND VGND VPWR VPWR _1443_/Q sky130_fd_sc_hd__dfstp_1
X_1374_ _0922_/C _1440_/Q _1601_/Q _1360_/A VGND VGND VPWR VPWR _1374_/X sky130_fd_sc_hd__o211a_1
XFILLER_23_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1090_ _1484_/Q _0867_/Y _0973_/X VGND VGND VPWR VPWR _1484_/D sky130_fd_sc_hd__a21o_1
X_0943_ _0943_/A _0943_/B _0943_/C _0943_/D VGND VGND VPWR VPWR _0947_/C sky130_fd_sc_hd__nand4_1
X_0874_ _1049_/A _0874_/B VGND VGND VPWR VPWR _0874_/Y sky130_fd_sc_hd__nor2_1
X_1426_ _1623_/Q _1622_/Q _1429_/S VGND VGND VPWR VPWR _1427_/A sky130_fd_sc_hd__mux2_1
X_1357_ _1357_/A _1357_/B _1357_/C _1356_/Y VGND VGND VPWR VPWR _1358_/A sky130_fd_sc_hd__or4b_1
X_1288_ _1288_/A VGND VGND VPWR VPWR _1557_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_55_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_320 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_287 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1142_ _1509_/Q _1499_/Q _1144_/S VGND VGND VPWR VPWR _1143_/A sky130_fd_sc_hd__mux2_1
X_1211_ _1158_/X _1157_/X _0831_/Y _0832_/Y VGND VGND VPWR VPWR _1533_/D sky130_fd_sc_hd__a211o_1
XFILLER_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1073_ _1471_/Q _1073_/B VGND VGND VPWR VPWR _1073_/Y sky130_fd_sc_hd__nand2_1
X_0857_ _0857_/A VGND VGND VPWR VPWR _0857_/X sky130_fd_sc_hd__dlymetal6s2s_1
X_0926_ _0862_/X _0924_/Y _0925_/X VGND VGND VPWR VPWR _1435_/D sky130_fd_sc_hd__o21bai_1
X_1409_ _0929_/X _0930_/X _0934_/C _1615_/Q _1402_/X VGND VGND VPWR VPWR _1409_/X
+ sky130_fd_sc_hd__o311a_1
X_0788_ _1436_/Q input9/X _1366_/A _0866_/B VGND VGND VPWR VPWR _0788_/X sky130_fd_sc_hd__a211o_1
XFILLER_43_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_62 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_117 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_320 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1125_ _1125_/A VGND VGND VPWR VPWR _1500_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_25_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1056_ _1078_/B VGND VGND VPWR VPWR _1080_/A sky130_fd_sc_hd__clkbuf_2
X_0909_ _1175_/A _1181_/B _1201_/B _1195_/D VGND VGND VPWR VPWR _1185_/A sky130_fd_sc_hd__nand4_1
Xoutput28 _1490_/Q VGND VGND VPWR VPWR data_out[5] sky130_fd_sc_hd__buf_2
Xoutput39 _1466_/Q VGND VGND VPWR VPWR transaction_active sky130_fd_sc_hd__buf_2
XFILLER_56_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1108_ _1493_/Q _1538_/Q _1108_/S VGND VGND VPWR VPWR _1109_/A sky130_fd_sc_hd__mux2_1
XFILLER_38_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1039_ _0968_/Y _1438_/Q _1253_/D VGND VGND VPWR VPWR _1043_/B sky130_fd_sc_hd__nand3b_1
XFILLER_21_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrepeater58 repeater59/X VGND VGND VPWR VPWR repeater58/X sky130_fd_sc_hd__clkbuf_2
Xrepeater47 _0928_/X VGND VGND VPWR VPWR repeater47/X sky130_fd_sc_hd__clkbuf_2
XFILLER_16_50 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xrepeater69 repeater74/X VGND VGND VPWR VPWR repeater69/X sky130_fd_sc_hd__clkbuf_2
XFILLER_32_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_179 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1390_ _1390_/A VGND VGND VPWR VPWR _1608_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_50_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1588_ _1624_/CLK _1588_/D repeater58/X VGND VGND VPWR VPWR _1588_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_7_190 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0890_ _1476_/Q _1477_/Q _1478_/Q VGND VGND VPWR VPWR _0963_/B sky130_fd_sc_hd__nor3_1
X_1511_ _1587_/CLK _1511_/D repeater59/X VGND VGND VPWR VPWR _1511_/Q sky130_fd_sc_hd__dfstp_1
X_1442_ _1442_/CLK _1442_/D repeater68/X VGND VGND VPWR VPWR _1442_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_4_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1373_ _1373_/A _1373_/B VGND VGND VPWR VPWR _1602_/D sky130_fd_sc_hd__xor2_1
XFILLER_48_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_145 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0942_ _0942_/A _0942_/B _0942_/C _0942_/D VGND VGND VPWR VPWR _0947_/B sky130_fd_sc_hd__nand4_1
XFILLER_9_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0873_ _0865_/X _0867_/Y _1440_/Q _0872_/X VGND VGND VPWR VPWR _1440_/D sky130_fd_sc_hd__a2bb2o_1
X_1425_ _1425_/A VGND VGND VPWR VPWR _1622_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_55_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1356_ _1599_/Q _1598_/Q _1355_/Y VGND VGND VPWR VPWR _1356_/Y sky130_fd_sc_hd__a21oi_1
X_1287_ _1556_/Q _1557_/Q _1291_/S VGND VGND VPWR VPWR _1288_/A sky130_fd_sc_hd__mux2_1
XFILLER_51_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_38 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1141_ _1141_/A VGND VGND VPWR VPWR _1508_/D sky130_fd_sc_hd__clkbuf_1
X_1210_ _1208_/X _1210_/B _1210_/C VGND VGND VPWR VPWR _1532_/D sky130_fd_sc_hd__nand3b_1
X_1072_ _0737_/A _1069_/Y _1071_/X input4/X VGND VGND VPWR VPWR _1072_/Y sky130_fd_sc_hd__a22oi_1
X_0856_ _0826_/Y _1512_/Q _0830_/X _1266_/B VGND VGND VPWR VPWR _1512_/D sky130_fd_sc_hd__o2bb2ai_1
X_0925_ _1084_/A _0977_/D _1054_/C VGND VGND VPWR VPWR _0925_/X sky130_fd_sc_hd__and3_1
X_0787_ _1394_/A _1394_/B _0740_/A _1360_/B VGND VGND VPWR VPWR _0866_/B sky130_fd_sc_hd__o211ai_1
X_1408_ _1613_/Q _1398_/X _1393_/X _1471_/Q _1407_/X VGND VGND VPWR VPWR _1613_/D
+ sky130_fd_sc_hd__a221o_1
X_1339_ _1581_/Q _1580_/Q _1343_/S VGND VGND VPWR VPWR _1340_/A sky130_fd_sc_hd__mux2_1
XFILLER_36_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1124_ _1500_/Q _1545_/Q _1138_/S VGND VGND VPWR VPWR _1125_/A sky130_fd_sc_hd__mux2_1
XFILLER_18_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1055_ _0977_/D _1041_/C _1060_/B _1054_/Y VGND VGND VPWR VPWR _1078_/B sky130_fd_sc_hd__o211ai_2
XFILLER_33_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_151 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput29 _1491_/Q VGND VGND VPWR VPWR data_out[6] sky130_fd_sc_hd__buf_2
X_0908_ _1522_/Q VGND VGND VPWR VPWR _1195_/D sky130_fd_sc_hd__inv_2
X_0839_ _0838_/A _1597_/Q _1596_/D VGND VGND VPWR VPWR _0839_/Y sky130_fd_sc_hd__a21oi_4
XFILLER_56_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_107 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_173 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_31 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1107_ _1107_/A VGND VGND VPWR VPWR _1492_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_53_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1038_ _0973_/B _0874_/Y _0742_/Y _0973_/A VGND VGND VPWR VPWR _1043_/A sky130_fd_sc_hd__o31ai_1
XFILLER_21_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrepeater59 repeater60/X VGND VGND VPWR VPWR repeater59/X sky130_fd_sc_hd__clkbuf_2
Xrepeater48 repeater50/X VGND VGND VPWR VPWR repeater48/X sky130_fd_sc_hd__clkbuf_2
XFILLER_8_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_268 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1587_ _1587_/CLK _1587_/D repeater58/X VGND VGND VPWR VPWR _1587_/Q sky130_fd_sc_hd__dfrtp_1
XTAP_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_53_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1510_ _1545_/CLK _1510_/D VGND VGND VPWR VPWR _1510_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_4_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1441_ _1532_/CLK _1441_/D _1053_/B1 VGND VGND VPWR VPWR _1441_/Q sky130_fd_sc_hd__dfrtp_1
Xclkbuf_4_5_0_clk_48 clkbuf_0_clk_48/X VGND VGND VPWR VPWR _1569_/CLK sky130_fd_sc_hd__clkbuf_8
X_1372_ _1372_/A _1372_/B _1372_/C _1372_/D VGND VGND VPWR VPWR _1373_/B sky130_fd_sc_hd__nand4_1
XFILLER_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0941_ _0941_/A _0941_/B _0941_/C _0941_/D VGND VGND VPWR VPWR _0947_/A sky130_fd_sc_hd__nand4_1
XFILLER_45_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0872_ _1370_/A _0930_/A _0931_/A _0879_/A VGND VGND VPWR VPWR _0872_/X sky130_fd_sc_hd__or4_1
X_1424_ _1622_/Q _1621_/Q _1424_/S VGND VGND VPWR VPWR _1425_/A sky130_fd_sc_hd__mux2_1
X_1355_ _1599_/Q _1598_/Q _1069_/A VGND VGND VPWR VPWR _1355_/Y sky130_fd_sc_hd__nor3b_1
XFILLER_36_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1286_ _1286_/A VGND VGND VPWR VPWR _1556_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_59_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_51 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1140_ _1508_/Q _1498_/Q _1144_/S VGND VGND VPWR VPWR _1141_/A sky130_fd_sc_hd__mux2_1
X_1071_ input9/X _1415_/B _1402_/A _1071_/D VGND VGND VPWR VPWR _1071_/X sky130_fd_sc_hd__and4_1
XFILLER_33_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0924_ _0774_/Y _0920_/X _0923_/Y VGND VGND VPWR VPWR _0924_/Y sky130_fd_sc_hd__a21oi_1
X_0855_ _0831_/Y _0832_/Y _0834_/X _0857_/A VGND VGND VPWR VPWR _1266_/B sky130_fd_sc_hd__o211ai_2
X_0786_ _1467_/Q VGND VGND VPWR VPWR _1360_/B sky130_fd_sc_hd__clkbuf_2
X_1338_ _1338_/A VGND VGND VPWR VPWR _1580_/D sky130_fd_sc_hd__clkbuf_1
X_1407_ _0929_/X _0930_/X _0934_/C _1614_/Q _1402_/X VGND VGND VPWR VPWR _1407_/X
+ sky130_fd_sc_hd__o311a_1
X_1269_ _1278_/S _1269_/B VGND VGND VPWR VPWR _1269_/Y sky130_fd_sc_hd__nand2_1
XFILLER_10_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1123_ _1123_/A VGND VGND VPWR VPWR _1138_/S sky130_fd_sc_hd__buf_2
XFILLER_33_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1054_ _1441_/Q _1054_/B _1054_/C VGND VGND VPWR VPWR _1054_/Y sky130_fd_sc_hd__nand3_1
X_0907_ _1524_/Q _1523_/Q _1525_/Q VGND VGND VPWR VPWR _1201_/B sky130_fd_sc_hd__nor3_2
XFILLER_31_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0769_ _1537_/Q _1536_/Q VGND VGND VPWR VPWR _0943_/C sky130_fd_sc_hd__or2b_1
X_0838_ _0838_/A _1597_/Q VGND VGND VPWR VPWR _0838_/Y sky130_fd_sc_hd__nor2_1
XFILLER_56_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_47_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1106_ _1492_/Q _1510_/Q _1108_/S VGND VGND VPWR VPWR _1107_/A sky130_fd_sc_hd__mux2_1
XFILLER_53_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1037_ _1037_/A _1037_/B VGND VGND VPWR VPWR _1037_/Y sky130_fd_sc_hd__nand2_1
XFILLER_21_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xrepeater49 repeater50/X VGND VGND VPWR VPWR repeater49/X sky130_fd_sc_hd__clkbuf_2
XFILLER_8_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1586_ _1624_/CLK _1586_/D repeater55/X VGND VGND VPWR VPWR _1586_/Q sky130_fd_sc_hd__dfrtp_1
XTAP_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1371_ _0929_/A _0930_/A _0931_/A _1360_/B _1402_/A VGND VGND VPWR VPWR _1372_/C
+ sky130_fd_sc_hd__o41a_1
X_1440_ _1626_/CLK _1440_/D repeater72/X VGND VGND VPWR VPWR _1440_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_31_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1569_ _1569_/CLK _1569_/D VGND VGND VPWR VPWR _1569_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_49_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0940_ _0938_/X _0939_/X _0937_/A VGND VGND VPWR VPWR _1588_/D sky130_fd_sc_hd__o21a_1
XFILLER_9_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_250 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_0871_ _0922_/C VGND VGND VPWR VPWR _0931_/A sky130_fd_sc_hd__dlymetal6s2s_1
X_1423_ _1423_/A VGND VGND VPWR VPWR _1621_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_48_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1354_ _1354_/A VGND VGND VPWR VPWR _1598_/D sky130_fd_sc_hd__clkbuf_1
X_1285_ _1555_/Q _1556_/Q _1291_/S VGND VGND VPWR VPWR _1286_/A sky130_fd_sc_hd__mux2_1
XFILLER_59_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_312 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_12 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_183 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1070_ _1070_/A VGND VGND VPWR VPWR _1402_/A sky130_fd_sc_hd__clkbuf_2
X_0854_ _0854_/A _0854_/B _0854_/C _0854_/D VGND VGND VPWR VPWR _0857_/A sky130_fd_sc_hd__nand4_4
X_0923_ _1435_/Q _0923_/B _0923_/C VGND VGND VPWR VPWR _0923_/Y sky130_fd_sc_hd__nand3b_1
X_0785_ _1607_/Q _1608_/Q VGND VGND VPWR VPWR _1394_/B sky130_fd_sc_hd__nand2_1
X_1337_ _1580_/Q _1242_/X _1343_/S VGND VGND VPWR VPWR _1338_/A sky130_fd_sc_hd__mux2_1
XFILLER_28_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1406_ _1612_/Q _1398_/X _1393_/X _1470_/Q _1405_/X VGND VGND VPWR VPWR _1612_/D
+ sky130_fd_sc_hd__a221o_1
X_1268_ _1309_/A VGND VGND VPWR VPWR _1278_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_43_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1199_ _1179_/B _1201_/B _1201_/C _1529_/Q VGND VGND VPWR VPWR _1199_/X sky130_fd_sc_hd__a31o_1
XFILLER_36_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_231 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1122_ _1122_/A VGND VGND VPWR VPWR _1499_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_2_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1053_ _1442_/Q _1436_/Q _1441_/Q _1053_/B1 VGND VGND VPWR VPWR _1060_/B sky130_fd_sc_hd__o31a_1
XFILLER_18_161 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0906_ _1520_/Q _1519_/Q _1521_/Q VGND VGND VPWR VPWR _1181_/B sky130_fd_sc_hd__nor3_2
X_0837_ _0838_/A _1597_/Q _1579_/Q _0744_/X VGND VGND VPWR VPWR _1259_/B sky130_fd_sc_hd__o211ai_2
X_0768_ _1504_/Q VGND VGND VPWR VPWR _0768_/Y sky130_fd_sc_hd__inv_2
XFILLER_56_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1105_ _1105_/A VGND VGND VPWR VPWR _1491_/D sky130_fd_sc_hd__clkbuf_1
X_1036_ _1032_/X _1033_/X _1034_/X _1463_/Q _1035_/X VGND VGND VPWR VPWR _1463_/D
+ sky130_fd_sc_hd__o32a_1
XFILLER_44_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_60 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1585_ _1625_/CLK _1585_/D repeater55/X VGND VGND VPWR VPWR _1585_/Q sky130_fd_sc_hd__dfrtp_1
XTAP_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_37_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1019_ _1019_/A VGND VGND VPWR VPWR _1457_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_27_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1370_ _1370_/A _1370_/B VGND VGND VPWR VPWR _1372_/B sky130_fd_sc_hd__nor2_1
XFILLER_31_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1499_ _1569_/CLK _1499_/D VGND VGND VPWR VPWR _1499_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_39_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1568_ _1577_/CLK _1568_/D VGND VGND VPWR VPWR _1568_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0870_ _1601_/Q VGND VGND VPWR VPWR _0930_/A sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_13_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1422_ _1621_/Q _1620_/Q _1424_/S VGND VGND VPWR VPWR _1423_/A sky130_fd_sc_hd__mux2_1
XFILLER_9_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1353_ _1357_/A _1353_/B _1357_/B _1357_/C VGND VGND VPWR VPWR _1354_/A sky130_fd_sc_hd__or4_1
X_1284_ _1284_/A VGND VGND VPWR VPWR _1555_/D sky130_fd_sc_hd__clkbuf_1
X_0999_ _1448_/Q _1447_/Q _0999_/S VGND VGND VPWR VPWR _1000_/A sky130_fd_sc_hd__mux2_1
XFILLER_42_324 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_24 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0853_ _0849_/Y _0850_/Y _0851_/Y _0852_/Y VGND VGND VPWR VPWR _0854_/D sky130_fd_sc_hd__o22a_1
X_0922_ _0929_/A _0930_/A _0922_/C _1437_/Q VGND VGND VPWR VPWR _0923_/C sky130_fd_sc_hd__or4b_1
XFILLER_5_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0784_ _1606_/Q VGND VGND VPWR VPWR _1394_/A sky130_fd_sc_hd__dlymetal6s2s_1
X_1405_ _0929_/X _0930_/X _0934_/C _1613_/Q _1402_/X VGND VGND VPWR VPWR _1405_/X
+ sky130_fd_sc_hd__o311a_1
X_1198_ _1529_/Q _1208_/B VGND VGND VPWR VPWR _1198_/Y sky130_fd_sc_hd__nand2_1
X_1267_ _1257_/Y _1248_/Y _1266_/Y VGND VGND VPWR VPWR _1548_/D sky130_fd_sc_hd__o21ai_1
X_1336_ _1579_/Q _0938_/X _1335_/X VGND VGND VPWR VPWR _1579_/D sky130_fd_sc_hd__o21a_1
Xinput1 data_in[0] VGND VGND VPWR VPWR input1/X sky130_fd_sc_hd__clkbuf_1
XFILLER_51_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1121_ _1499_/Q _1544_/Q _1121_/S VGND VGND VPWR VPWR _1122_/A sky130_fd_sc_hd__mux2_1
X_1052_ _1052_/A VGND VGND VPWR VPWR _1052_/X sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_25_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0905_ _1515_/Q _1516_/Q _1518_/Q _1517_/Q VGND VGND VPWR VPWR _1175_/A sky130_fd_sc_hd__nor4_2
X_0767_ _0942_/C _0767_/B _0942_/D _0943_/B VGND VGND VPWR VPWR _0773_/A sky130_fd_sc_hd__nand4_1
X_0836_ _0852_/A _1569_/Q VGND VGND VPWR VPWR _0836_/X sky130_fd_sc_hd__and2b_2
XFILLER_56_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1319_ _1319_/A VGND VGND VPWR VPWR _1571_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_8_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1104_ _1491_/Q _1509_/Q _1108_/S VGND VGND VPWR VPWR _1105_/A sky130_fd_sc_hd__mux2_1
XFILLER_53_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1035_ _0972_/C _0747_/Y _0943_/C _1030_/S VGND VGND VPWR VPWR _1035_/X sky130_fd_sc_hd__a2bb2o_1
X_0819_ _1619_/Q _1620_/Q _0819_/C _0819_/D VGND VGND VPWR VPWR _0918_/A sky130_fd_sc_hd__and4b_1
XFILLER_29_268 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_202 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_72 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1584_ _1624_/CLK _1584_/D repeater55/X VGND VGND VPWR VPWR _1584_/Q sky130_fd_sc_hd__dfrtp_1
XTAP_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1018_ _1457_/Q _1456_/Q _1021_/S VGND VGND VPWR VPWR _1019_/A sky130_fd_sc_hd__mux2_1
Xclkbuf_4_10_0_clk_48 clkbuf_0_clk_48/X VGND VGND VPWR VPWR _1618_/CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_1_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_30 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1567_ _1577_/CLK _1567_/D VGND VGND VPWR VPWR _1567_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1498_ _1569_/CLK _1498_/D VGND VGND VPWR VPWR _1498_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_14_219 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1421_ _1421_/A VGND VGND VPWR VPWR _1620_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_55_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1352_ _1069_/A _1599_/Q _1598_/Q VGND VGND VPWR VPWR _1353_/B sky130_fd_sc_hd__o21ba_1
X_1283_ _1554_/Q _1555_/Q _1291_/S VGND VGND VPWR VPWR _1284_/A sky130_fd_sc_hd__mux2_1
X_0998_ _0998_/A VGND VGND VPWR VPWR _1447_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_59_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1619_ _1624_/CLK _1619_/D repeater57/X VGND VGND VPWR VPWR _1619_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_42_336 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_36 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0921_ _1438_/Q _0952_/C VGND VGND VPWR VPWR _0923_/B sky130_fd_sc_hd__nand2_1
XFILLER_53_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_0852_ _0852_/A _1572_/Q _1568_/Q VGND VGND VPWR VPWR _0852_/Y sky130_fd_sc_hd__nor3b_1
X_0783_ _0783_/A _0783_/B _0783_/C _0783_/D VGND VGND VPWR VPWR _1366_/A sky130_fd_sc_hd__nand4_4
X_1335_ _1587_/Q _1588_/Q _1589_/D VGND VGND VPWR VPWR _1335_/X sky130_fd_sc_hd__or3_1
X_1404_ _1611_/Q _1398_/X _1393_/X _1469_/Q _1403_/X VGND VGND VPWR VPWR _1611_/D
+ sky130_fd_sc_hd__a221o_1
Xinput2 data_in[1] VGND VGND VPWR VPWR input2/X sky130_fd_sc_hd__dlymetal6s2s_1
X_1197_ _1195_/Y _1196_/Y _1150_/B VGND VGND VPWR VPWR _1528_/D sky130_fd_sc_hd__a21oi_1
X_1266_ _1260_/Y _1266_/B _1266_/C _1266_/D VGND VGND VPWR VPWR _1266_/Y sky130_fd_sc_hd__nand4b_1
XFILLER_51_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_133 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1120_ _1120_/A VGND VGND VPWR VPWR _1498_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_33_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1051_ input9/X _1415_/B _1070_/A _1071_/D VGND VGND VPWR VPWR _1052_/A sky130_fd_sc_hd__nand4_2
XFILLER_18_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0904_ _1041_/B _0952_/C _1440_/Q _0879_/Y VGND VGND VPWR VPWR _1438_/D sky130_fd_sc_hd__a2bb2o_1
X_0766_ _1507_/Q _0757_/A VGND VGND VPWR VPWR _0943_/B sky130_fd_sc_hd__or2b_1
X_0835_ _1549_/Q VGND VGND VPWR VPWR _0852_/A sky130_fd_sc_hd__dlymetal6s2s_1
X_1318_ _1228_/X _1571_/Q _1320_/S VGND VGND VPWR VPWR _1319_/A sky130_fd_sc_hd__mux2_1
XPHY_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1249_ _1259_/C _1578_/Q _1259_/B VGND VGND VPWR VPWR _1252_/A sky130_fd_sc_hd__nand3_1
XFILLER_12_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_239 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1103_ _1103_/A VGND VGND VPWR VPWR _1490_/D sky130_fd_sc_hd__clkbuf_1
X_1034_ _0972_/C _0972_/B _0747_/Y VGND VGND VPWR VPWR _1034_/X sky130_fd_sc_hd__a21o_1
Xclkbuf_4_8_0_clk_48 clkbuf_0_clk_48/X VGND VGND VPWR VPWR _1626_/CLK sky130_fd_sc_hd__clkbuf_8
X_0818_ _1621_/Q _1625_/Q _1624_/Q _1622_/Q VGND VGND VPWR VPWR _0819_/D sky130_fd_sc_hd__and4bb_1
X_0749_ _1536_/Q VGND VGND VPWR VPWR _1033_/B sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_44_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_84 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1583_ _1624_/CLK _1583_/D repeater55/X VGND VGND VPWR VPWR _1583_/Q sky130_fd_sc_hd__dfrtp_1
XTAP_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_41_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1017_ _1017_/A VGND VGND VPWR VPWR _1456_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_1_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_305 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_4_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1497_ _1569_/CLK _1497_/D VGND VGND VPWR VPWR _1497_/Q sky130_fd_sc_hd__dfxtp_1
X_1566_ _1578_/CLK _1566_/D VGND VGND VPWR VPWR _1566_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_146 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1351_ _1351_/A VGND VGND VPWR VPWR _1586_/D sky130_fd_sc_hd__clkbuf_1
X_1420_ _1620_/Q _1619_/Q _1424_/S VGND VGND VPWR VPWR _1421_/A sky130_fd_sc_hd__mux2_1
XFILLER_48_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1282_ _1282_/A VGND VGND VPWR VPWR _1554_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_51_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_0997_ _1447_/Q _1446_/Q _0999_/S VGND VGND VPWR VPWR _0998_/A sky130_fd_sc_hd__mux2_1
X_1618_ _1618_/CLK _1618_/D VGND VGND VPWR VPWR _1618_/Q sky130_fd_sc_hd__dfxtp_1
X_1549_ _1577_/CLK _1549_/D _0927_/B VGND VGND VPWR VPWR _1549_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_54_175 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0920_ _0970_/C _1037_/A VGND VGND VPWR VPWR _0920_/X sky130_fd_sc_hd__and2b_1
X_0851_ _0852_/A _1568_/Q _1572_/Q VGND VGND VPWR VPWR _0851_/Y sky130_fd_sc_hd__nor3b_1
X_0782_ _1618_/Q VGND VGND VPWR VPWR _0783_/D sky130_fd_sc_hd__inv_2
XFILLER_46_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1334_ _1334_/A VGND VGND VPWR VPWR _1578_/D sky130_fd_sc_hd__clkbuf_1
X_1403_ _0929_/X _0930_/X _0934_/C _1612_/Q _1402_/X VGND VGND VPWR VPWR _1403_/X
+ sky130_fd_sc_hd__o311a_1
X_1265_ _1265_/A _1265_/B _1265_/C _1265_/D VGND VGND VPWR VPWR _1266_/D sky130_fd_sc_hd__nor4_1
X_1196_ _1527_/Q _1188_/X _1528_/Q VGND VGND VPWR VPWR _1196_/Y sky130_fd_sc_hd__o21ai_1
Xinput3 data_in[2] VGND VGND VPWR VPWR input3/X sky130_fd_sc_hd__clkbuf_1
XFILLER_24_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_201 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_156 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1050_ _1606_/Q _1394_/B _0740_/A VGND VGND VPWR VPWR _1070_/A sky130_fd_sc_hd__o21a_1
XFILLER_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0834_ _1239_/A _1573_/Q _1513_/Q VGND VGND VPWR VPWR _0834_/X sky130_fd_sc_hd__and3b_1
XFILLER_33_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0903_ _0963_/B _0963_/C _0903_/C _0963_/D VGND VGND VPWR VPWR _0952_/C sky130_fd_sc_hd__and4_1
XFILLER_21_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0765_ _1508_/Q _0763_/A VGND VGND VPWR VPWR _0942_/D sky130_fd_sc_hd__or2b_1
XFILLER_56_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1248_ _0918_/B _0857_/A _0834_/X _1247_/Y VGND VGND VPWR VPWR _1248_/Y sky130_fd_sc_hd__a31oi_1
X_1317_ _1317_/A VGND VGND VPWR VPWR _1570_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_2_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1179_ _1523_/Q _1179_/B VGND VGND VPWR VPWR _1179_/Y sky130_fd_sc_hd__nand2_1
XFILLER_24_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_46_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1102_ _1490_/Q _1508_/Q _1108_/S VGND VGND VPWR VPWR _1103_/A sky130_fd_sc_hd__mux2_1
XFILLER_38_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1033_ _1032_/B _1033_/B VGND VGND VPWR VPWR _1033_/X sky130_fd_sc_hd__and2b_1
X_0817_ _1587_/Q _1588_/Q _1623_/Q VGND VGND VPWR VPWR _0819_/C sky130_fd_sc_hd__nor3_1
X_0748_ _1535_/Q VGND VGND VPWR VPWR _0972_/B sky130_fd_sc_hd__clkbuf_2
XFILLER_37_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_240 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_30 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_270 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1582_ _1624_/CLK _1582_/D repeater55/X VGND VGND VPWR VPWR _1582_/Q sky130_fd_sc_hd__dfrtp_1
XTAP_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_19_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_273 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1016_ _1456_/Q _1455_/Q _1021_/S VGND VGND VPWR VPWR _1017_/A sky130_fd_sc_hd__mux2_1
XFILLER_1_317 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_166 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_4_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1496_ _1569_/CLK _1496_/D VGND VGND VPWR VPWR _1496_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_39_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1565_ _1578_/CLK _1565_/D repeater46/X VGND VGND VPWR VPWR _1565_/Q sky130_fd_sc_hd__dfstp_1
XTAP_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1350_ _1586_/Q _1585_/Q _1424_/S VGND VGND VPWR VPWR _1351_/A sky130_fd_sc_hd__mux2_1
X_1281_ _1553_/Q _1554_/Q _1291_/S VGND VGND VPWR VPWR _1282_/A sky130_fd_sc_hd__mux2_1
XFILLER_48_162 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0996_ _0996_/A VGND VGND VPWR VPWR _1446_/D sky130_fd_sc_hd__clkbuf_1
X_1617_ _1618_/CLK _1617_/D VGND VGND VPWR VPWR _1617_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_39_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1548_ _1576_/CLK _1548_/D repeater61/X VGND VGND VPWR VPWR _1548_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_27_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1479_ _1487_/CLK _1479_/D repeater75/X VGND VGND VPWR VPWR _1479_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_54_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_55 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_10_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_0850_ _0852_/A _1571_/Q _1567_/Q VGND VGND VPWR VPWR _0850_/Y sky130_fd_sc_hd__nor3b_1
X_1402_ _1402_/A VGND VGND VPWR VPWR _1402_/X sky130_fd_sc_hd__dlymetal6s2s_1
X_0781_ _1617_/Q _1616_/Q VGND VGND VPWR VPWR _0783_/C sky130_fd_sc_hd__nor2_1
X_1333_ _1577_/Q _1578_/Q _1333_/S VGND VGND VPWR VPWR _1334_/A sky130_fd_sc_hd__mux2_1
Xinput4 data_in[3] VGND VGND VPWR VPWR input4/X sky130_fd_sc_hd__clkbuf_1
X_1264_ _1551_/Q _1550_/Q _1552_/Q _1222_/C VGND VGND VPWR VPWR _1265_/D sky130_fd_sc_hd__or4bb_1
X_1195_ _1195_/A _1201_/B _1201_/C _1195_/D VGND VGND VPWR VPWR _1195_/Y sky130_fd_sc_hd__nand4_1
XFILLER_36_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0979_ _0732_/X _0778_/X _0889_/X _0977_/X _1433_/Q VGND VGND VPWR VPWR _0979_/X
+ sky130_fd_sc_hd__a311o_1
XFILLER_59_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_176 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_168 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_42_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0833_ _1549_/Q VGND VGND VPWR VPWR _1239_/A sky130_fd_sc_hd__dlymetal6s2s_1
X_0902_ _1514_/Q _1438_/Q VGND VGND VPWR VPWR _1041_/B sky130_fd_sc_hd__or2b_1
X_0764_ _1504_/Q _0945_/A VGND VGND VPWR VPWR _0767_/B sky130_fd_sc_hd__or2b_1
X_1178_ _1175_/A _1181_/B _1195_/D _1523_/Q VGND VGND VPWR VPWR _1178_/X sky130_fd_sc_hd__a31o_1
X_1247_ _1253_/D _0859_/C _1127_/B _1222_/B _1222_/A VGND VGND VPWR VPWR _1247_/Y
+ sky130_fd_sc_hd__o2111ai_1
X_1316_ _0836_/X _1570_/Q _1320_/S VGND VGND VPWR VPWR _1317_/A sky130_fd_sc_hd__mux2_1
XPHY_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_168 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_124 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1101_ _1101_/A VGND VGND VPWR VPWR _1489_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_38_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1032_ _1033_/B _1032_/B VGND VGND VPWR VPWR _1032_/X sky130_fd_sc_hd__and2b_1
X_0816_ _1357_/C VGND VGND VPWR VPWR _1159_/A sky130_fd_sc_hd__clkbuf_2
X_0747_ _1514_/Q _1439_/Q VGND VGND VPWR VPWR _0747_/Y sky130_fd_sc_hd__nand2b_2
XFILLER_4_315 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_42 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_230 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_282 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1581_ _1624_/CLK _1581_/D repeater57/X VGND VGND VPWR VPWR _1581_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_7_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1015_ _1015_/A VGND VGND VPWR VPWR _1455_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_34_285 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1564_ _1578_/CLK _1564_/D repeater47/X VGND VGND VPWR VPWR _1564_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_54_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1495_ _1569_/CLK _1495_/D VGND VGND VPWR VPWR _1495_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_49_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1280_ _1309_/A VGND VGND VPWR VPWR _1291_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_48_174 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_0995_ _1446_/Q _1445_/Q _0999_/S VGND VGND VPWR VPWR _0996_/A sky130_fd_sc_hd__mux2_1
X_1547_ _1576_/CLK _1547_/D repeater61/X VGND VGND VPWR VPWR _1547_/Q sky130_fd_sc_hd__dfrtp_1
X_1616_ _1618_/CLK _1616_/D VGND VGND VPWR VPWR _1616_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_54_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1478_ _1559_/CLK _1478_/D repeater75/X VGND VGND VPWR VPWR _1478_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_50_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_67 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_218 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0780_ _1615_/Q _1614_/Q VGND VGND VPWR VPWR _0783_/B sky130_fd_sc_hd__nor2_1
XFILLER_5_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1401_ _1610_/Q _1398_/X _1400_/X VGND VGND VPWR VPWR _1610_/D sky130_fd_sc_hd__a21o_1
X_1194_ _1526_/Q _1528_/Q _1527_/Q VGND VGND VPWR VPWR _1201_/C sky130_fd_sc_hd__nor3_1
Xinput5 data_in[4] VGND VGND VPWR VPWR input5/X sky130_fd_sc_hd__clkbuf_2
X_1332_ _1332_/A VGND VGND VPWR VPWR _1577_/D sky130_fd_sc_hd__clkbuf_1
X_1263_ _1554_/Q _1553_/Q _1556_/Q _1555_/Q VGND VGND VPWR VPWR _1265_/C sky130_fd_sc_hd__or4_1
XFILLER_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0978_ _0732_/X _0778_/X _0889_/X _0977_/X VGND VGND VPWR VPWR _0978_/Y sky130_fd_sc_hd__a31oi_1
XFILLER_10_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0763_ _0763_/A _1508_/Q VGND VGND VPWR VPWR _0942_/C sky130_fd_sc_hd__or2b_1
X_0832_ _0832_/A _0832_/B VGND VGND VPWR VPWR _0832_/Y sky130_fd_sc_hd__nor2_1
X_0901_ _0862_/X _1037_/A _0899_/Y _0900_/Y _0735_/X VGND VGND VPWR VPWR _1439_/D
+ sky130_fd_sc_hd__a32o_1
X_1315_ _1315_/A VGND VGND VPWR VPWR _1569_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_56_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1177_ _1158_/X _1157_/X _1179_/B _1176_/X _1159_/A VGND VGND VPWR VPWR _1522_/D
+ sky130_fd_sc_hd__o221a_1
X_1246_ _1547_/Q VGND VGND VPWR VPWR _1246_/Y sky130_fd_sc_hd__inv_2
XPHY_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_13_0_clk_48 clkbuf_0_clk_48/X VGND VGND VPWR VPWR _1624_/CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_15_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_302 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1031_ _1031_/A VGND VGND VPWR VPWR _1462_/D sky130_fd_sc_hd__clkbuf_1
X_1100_ _1489_/Q _1507_/Q _1108_/S VGND VGND VPWR VPWR _1101_/A sky130_fd_sc_hd__mux2_1
X_0815_ _0832_/A _0832_/B _0813_/X _0814_/Y VGND VGND VPWR VPWR _1357_/C sky130_fd_sc_hd__o22a_1
X_0746_ _0823_/A VGND VGND VPWR VPWR _1589_/D sky130_fd_sc_hd__inv_2
XFILLER_52_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1229_ _1228_/X _1540_/Q _1234_/S VGND VGND VPWR VPWR _1230_/A sky130_fd_sc_hd__mux2_1
XFILLER_4_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_327 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1580_ _1624_/CLK _1580_/D repeater57/X VGND VGND VPWR VPWR _1580_/Q sky130_fd_sc_hd__dfrtp_1
XTAP_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1014_ _1455_/Q _1454_/Q _1021_/S VGND VGND VPWR VPWR _1015_/A sky130_fd_sc_hd__mux2_1
XFILLER_34_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0729_ _1480_/Q VGND VGND VPWR VPWR _0730_/C sky130_fd_sc_hd__inv_2
XFILLER_57_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_212 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1494_ _1569_/CLK _1494_/D VGND VGND VPWR VPWR _1494_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1563_ _1578_/CLK _1563_/D repeater47/X VGND VGND VPWR VPWR _1563_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_58_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_4_1_0_clk_48 clkbuf_0_clk_48/X VGND VGND VPWR VPWR _1578_/CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_1_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0994_ _0994_/A VGND VGND VPWR VPWR _1445_/D sky130_fd_sc_hd__clkbuf_1
X_1546_ _1576_/CLK _1546_/D repeater61/X VGND VGND VPWR VPWR _1546_/Q sky130_fd_sc_hd__dfrtp_2
X_1615_ _1618_/CLK _1615_/D VGND VGND VPWR VPWR _1615_/Q sky130_fd_sc_hd__dfxtp_1
X_1477_ _1559_/CLK _1477_/D repeater75/X VGND VGND VPWR VPWR _1477_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_42_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1331_ _1576_/Q _1577_/Q _1333_/S VGND VGND VPWR VPWR _1332_/A sky130_fd_sc_hd__mux2_1
X_1400_ _1468_/Q _1366_/A _1392_/C _1399_/X VGND VGND VPWR VPWR _1400_/X sky130_fd_sc_hd__o211a_1
X_1193_ _0915_/A _1191_/X _1192_/Y _0918_/B VGND VGND VPWR VPWR _1527_/D sky130_fd_sc_hd__a31o_1
XFILLER_36_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput6 data_in[5] VGND VGND VPWR VPWR input6/X sky130_fd_sc_hd__clkbuf_1
X_1262_ _1558_/Q _1557_/Q _1560_/Q _1559_/Q VGND VGND VPWR VPWR _1265_/B sky130_fd_sc_hd__or4_1
XFILLER_51_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0977_ _1435_/Q _1049_/A _1436_/Q _0977_/D VGND VGND VPWR VPWR _0977_/X sky130_fd_sc_hd__and4b_1
XFILLER_10_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1529_ _1600_/CLK _1529_/D repeater63/X VGND VGND VPWR VPWR _1529_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_19_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_123 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0900_ _0895_/Y _0737_/X _0948_/B VGND VGND VPWR VPWR _0900_/Y sky130_fd_sc_hd__o21ai_1
X_0762_ _0762_/A _0762_/B VGND VGND VPWR VPWR _0774_/B sky130_fd_sc_hd__nor2_1
X_0831_ _0832_/A hold1/A _0813_/X VGND VGND VPWR VPWR _0831_/Y sky130_fd_sc_hd__a21oi_2
XFILLER_44_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1314_ _1233_/X _1569_/Q _1320_/S VGND VGND VPWR VPWR _1315_/A sky130_fd_sc_hd__mux2_1
XFILLER_49_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1176_ _1520_/Q _1168_/B _1521_/Q _1168_/C _1522_/Q VGND VGND VPWR VPWR _1176_/X
+ sky130_fd_sc_hd__o41a_1
X_1245_ _1546_/Q _0830_/X _1234_/S VGND VGND VPWR VPWR _1546_/D sky130_fd_sc_hd__a21bo_1
XFILLER_2_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_7_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1030_ _1462_/Q _1495_/Q _1030_/S VGND VGND VPWR VPWR _1031_/A sky130_fd_sc_hd__mux2_1
X_0814_ _0811_/A _0811_/B hold1/A VGND VGND VPWR VPWR _0814_/Y sky130_fd_sc_hd__a21boi_2
Xinput20 usb_address[4] VGND VGND VPWR VPWR _0757_/A sky130_fd_sc_hd__dlymetal6s2s_1
X_0745_ _0838_/A _1597_/Q _0744_/X VGND VGND VPWR VPWR _0823_/A sky130_fd_sc_hd__o21ai_2
X_1228_ _1269_/B _1570_/Q VGND VGND VPWR VPWR _1228_/X sky130_fd_sc_hd__and2b_1
XFILLER_52_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_210 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1159_ _1159_/A VGND VGND VPWR VPWR _1210_/C sky130_fd_sc_hd__clkbuf_2
XFILLER_16_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_339 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_184 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1013_ _1013_/A VGND VGND VPWR VPWR _1454_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_19_262 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_0728_ _1479_/Q _1478_/Q VGND VGND VPWR VPWR _0730_/B sky130_fd_sc_hd__nor2_1
XFILLER_40_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1493_ _1569_/CLK _1493_/D VGND VGND VPWR VPWR _1493_/Q sky130_fd_sc_hd__dfxtp_1
X_1562_ _1578_/CLK _1562_/D repeater45/X VGND VGND VPWR VPWR _1562_/Q sky130_fd_sc_hd__dfstp_1
XTAP_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_13_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0993_ _1445_/Q _0992_/X _0999_/S VGND VGND VPWR VPWR _0994_/A sky130_fd_sc_hd__mux2_1
XFILLER_8_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_294 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1614_ _1618_/CLK _1614_/D VGND VGND VPWR VPWR _1614_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_12_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1545_ _1545_/CLK _1545_/D repeater52/X VGND VGND VPWR VPWR _1545_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_39_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1476_ _1487_/CLK _1476_/D repeater75/X VGND VGND VPWR VPWR _1476_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_27_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1330_ _1328_/Y _0830_/X _1255_/B _1329_/X VGND VGND VPWR VPWR _1576_/D sky130_fd_sc_hd__o31a_1
XFILLER_30_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1261_ _1562_/Q _1561_/Q _1563_/Q VGND VGND VPWR VPWR _1265_/A sky130_fd_sc_hd__or3_1
X_1192_ _1526_/Q _1191_/A _1527_/Q VGND VGND VPWR VPWR _1192_/Y sky130_fd_sc_hd__o21bai_1
Xinput7 data_in[6] VGND VGND VPWR VPWR input7/X sky130_fd_sc_hd__clkbuf_1
XFILLER_24_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0976_ _1431_/S _0976_/B VGND VGND VPWR VPWR _1605_/D sky130_fd_sc_hd__nor2_1
X_1459_ _1545_/CLK _1459_/D repeater52/X VGND VGND VPWR VPWR _1459_/Q sky130_fd_sc_hd__dfrtp_1
X_1528_ _1625_/CLK _1528_/D repeater64/X VGND VGND VPWR VPWR _1528_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_35_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_308 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0830_ _1333_/S VGND VGND VPWR VPWR _0830_/X sky130_fd_sc_hd__clkbuf_2
X_0761_ _0943_/A _0941_/C _0761_/C _0761_/D VGND VGND VPWR VPWR _0762_/B sky130_fd_sc_hd__nand4_1
X_1244_ _1244_/A VGND VGND VPWR VPWR _1545_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_49_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1313_ _1313_/A VGND VGND VPWR VPWR _1568_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_37_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1175_ _1175_/A _1181_/B _1195_/D VGND VGND VPWR VPWR _1179_/B sky130_fd_sc_hd__and3_1
XFILLER_24_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0959_ _0952_/C _0958_/Y _0967_/A VGND VGND VPWR VPWR _1479_/D sky130_fd_sc_hd__o21ai_1
XFILLER_20_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput10 data_toggle VGND VGND VPWR VPWR _0737_/A sky130_fd_sc_hd__clkbuf_2
X_0813_ _1594_/Q _1591_/D _1594_/D hold3/A VGND VGND VPWR VPWR _0813_/X sky130_fd_sc_hd__a31o_1
XFILLER_14_182 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_119 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput21 usb_address[5] VGND VGND VPWR VPWR _0763_/A sky130_fd_sc_hd__clkbuf_1
X_0744_ hold2/A _1597_/Q _1596_/D VGND VGND VPWR VPWR _0744_/X sky130_fd_sc_hd__a21o_1
X_1227_ _1227_/A VGND VGND VPWR VPWR _1539_/D sky130_fd_sc_hd__clkbuf_1
X_1158_ _1158_/A VGND VGND VPWR VPWR _1158_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_52_222 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_38 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1089_ _1033_/B _1032_/B _1030_/S _1088_/X VGND VGND VPWR VPWR _1483_/D sky130_fd_sc_hd__a31o_1
XFILLER_43_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_178 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1012_ _1454_/Q _1453_/Q _1012_/S VGND VGND VPWR VPWR _1013_/A sky130_fd_sc_hd__mux2_1
XFILLER_19_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0727_ _1476_/Q _1477_/Q VGND VGND VPWR VPWR _0730_/A sky130_fd_sc_hd__nor2_1
XFILLER_57_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_16_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1492_ _1624_/CLK _1492_/D VGND VGND VPWR VPWR _1492_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_39_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1561_ _1578_/CLK _1561_/D repeater45/X VGND VGND VPWR VPWR _1561_/Q sky130_fd_sc_hd__dfstp_1
XTAP_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_1_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_173 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_0992_ _1444_/Q _1020_/B VGND VGND VPWR VPWR _0992_/X sky130_fd_sc_hd__xor2_1
X_1544_ _1569_/CLK _1544_/D repeater53/X VGND VGND VPWR VPWR _1544_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_5_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1613_ _1618_/CLK _1613_/D VGND VGND VPWR VPWR _1613_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_8_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_144 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1475_ _1532_/CLK _1475_/D VGND VGND VPWR VPWR _1475_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_54_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1191_ _1191_/A _1526_/Q _1527_/Q VGND VGND VPWR VPWR _1191_/X sky130_fd_sc_hd__or3b_1
Xinput8 data_in[7] VGND VGND VPWR VPWR input8/X sky130_fd_sc_hd__clkbuf_1
X_1260_ _1564_/Q _1260_/B _1260_/C VGND VGND VPWR VPWR _1260_/Y sky130_fd_sc_hd__nand3b_1
XFILLER_36_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_103 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0975_ _1397_/A _1605_/Q VGND VGND VPWR VPWR _0976_/B sky130_fd_sc_hd__and2_1
X_1527_ _1625_/CLK _1527_/D repeater64/X VGND VGND VPWR VPWR _1527_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_10_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1458_ _1487_/CLK _1458_/D _0932_/X VGND VGND VPWR VPWR _1458_/Q sky130_fd_sc_hd__dfstp_1
X_1389_ _1389_/A _1389_/B _1389_/C VGND VGND VPWR VPWR _1390_/A sky130_fd_sc_hd__and3_1
XFILLER_50_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0760_ _1502_/Q _1547_/Q VGND VGND VPWR VPWR _0761_/D sky130_fd_sc_hd__and2_1
XFILLER_41_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1243_ _1242_/X _1545_/Q _1243_/S VGND VGND VPWR VPWR _1244_/A sky130_fd_sc_hd__mux2_1
X_1174_ _1195_/A _1173_/X _1158_/X _1157_/X _1159_/A VGND VGND VPWR VPWR _1521_/D
+ sky130_fd_sc_hd__o221a_1
X_1312_ _1236_/X _1568_/Q _1320_/S VGND VGND VPWR VPWR _1313_/A sky130_fd_sc_hd__mux2_1
XFILLER_2_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0958_ _0730_/A _0730_/B _0957_/X VGND VGND VPWR VPWR _0958_/Y sky130_fd_sc_hd__a21oi_1
X_0889_ _0948_/B _1435_/Q _1222_/C VGND VGND VPWR VPWR _0889_/X sky130_fd_sc_hd__and3_1
XFILLER_55_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_19 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_11_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput22 usb_address[6] VGND VGND VPWR VPWR _0753_/A sky130_fd_sc_hd__clkbuf_1
X_0812_ _1594_/Q _1591_/D _1594_/D hold1/A VGND VGND VPWR VPWR _0832_/B sky130_fd_sc_hd__o31a_1
Xinput11 handshake[0] VGND VGND VPWR VPWR _0874_/B sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_14_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0743_ _0732_/X _0735_/X _0737_/X _0742_/Y _1442_/Q VGND VGND VPWR VPWR _1442_/D
+ sky130_fd_sc_hd__a32o_1
XFILLER_52_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1226_ _1215_/X _1539_/Q _1234_/S VGND VGND VPWR VPWR _1227_/A sky130_fd_sc_hd__mux2_1
X_1157_ _1533_/Q VGND VGND VPWR VPWR _1157_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1088_ _0972_/C _0747_/Y _1033_/X _1034_/X _1483_/Q VGND VGND VPWR VPWR _1088_/X
+ sky130_fd_sc_hd__o221a_1
XFILLER_43_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1011_ _1011_/A VGND VGND VPWR VPWR _1453_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_19_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0726_ _1397_/A VGND VGND VPWR VPWR _1604_/D sky130_fd_sc_hd__clkinv_2
XFILLER_57_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1209_ _1531_/Q _1205_/B _1532_/Q VGND VGND VPWR VPWR _1210_/B sky130_fd_sc_hd__o21ai_1
XFILLER_25_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1560_ _1578_/CLK _1560_/D repeater45/X VGND VGND VPWR VPWR _1560_/Q sky130_fd_sc_hd__dfstp_1
X_1491_ _1545_/CLK _1491_/D VGND VGND VPWR VPWR _1491_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_3_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0991_ _0991_/A VGND VGND VPWR VPWR _1444_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_12_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1543_ _1569_/CLK _1543_/D repeater53/X VGND VGND VPWR VPWR _1543_/Q sky130_fd_sc_hd__dfrtp_1
X_1474_ _1532_/CLK _1474_/D VGND VGND VPWR VPWR _1474_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_5_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1612_ _1618_/CLK _1612_/D VGND VGND VPWR VPWR _1612_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_8_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_156 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput9 data_in_valid VGND VGND VPWR VPWR input9/X sky130_fd_sc_hd__buf_2
X_1190_ _1188_/X _1189_/Y _1150_/B VGND VGND VPWR VPWR _1526_/D sky130_fd_sc_hd__a21oi_1
XFILLER_44_170 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0974_ _1037_/A _1095_/S _0972_/X _0973_/X VGND VGND VPWR VPWR _1464_/D sky130_fd_sc_hd__a31o_1
X_1526_ _1625_/CLK _1526_/D repeater64/X VGND VGND VPWR VPWR _1526_/Q sky130_fd_sc_hd__dfrtp_1
X_1457_ _1487_/CLK _1457_/D _0932_/X VGND VGND VPWR VPWR _1457_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_35_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1388_ _1394_/A _1607_/Q _1608_/Q _1431_/S VGND VGND VPWR VPWR _1389_/C sky130_fd_sc_hd__nand4_1
XPHY_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1311_ _1311_/A VGND VGND VPWR VPWR _1567_/D sky130_fd_sc_hd__clkbuf_1
X_1173_ _1520_/Q _1168_/B _1168_/C _1521_/Q VGND VGND VPWR VPWR _1173_/X sky130_fd_sc_hd__o31a_1
X_1242_ _0839_/Y _0846_/Y _0847_/Y VGND VGND VPWR VPWR _1242_/X sky130_fd_sc_hd__o21a_1
XFILLER_32_162 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_0957_ _1476_/Q _1477_/Q _1478_/Q _1479_/Q VGND VGND VPWR VPWR _0957_/X sky130_fd_sc_hd__o31a_1
X_0888_ _1535_/Q _1534_/Q VGND VGND VPWR VPWR _0948_/B sky130_fd_sc_hd__or2b_1
X_1509_ _1545_/CLK _1509_/D VGND VGND VPWR VPWR _1509_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_55_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput12 handshake[1] VGND VGND VPWR VPWR _1049_/A sky130_fd_sc_hd__buf_2
X_0811_ _0811_/A _0811_/B VGND VGND VPWR VPWR _0832_/A sky130_fd_sc_hd__nand2_2
X_0742_ _1415_/B _1431_/S _1071_/D _0934_/B VGND VGND VPWR VPWR _0742_/Y sky130_fd_sc_hd__nand4_4
XFILLER_42_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1156_ _1164_/A _1164_/B _1517_/Q VGND VGND VPWR VPWR _1156_/X sky130_fd_sc_hd__o21a_1
X_1225_ _1225_/A VGND VGND VPWR VPWR _1538_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_37_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_37_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1087_ _1475_/Q _1061_/Y _1084_/Y _1086_/Y VGND VGND VPWR VPWR _1475_/D sky130_fd_sc_hd__o211a_1
XFILLER_20_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_4_0_clk_48 clkbuf_0_clk_48/X VGND VGND VPWR VPWR _1577_/CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_11_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1010_ _1453_/Q _1452_/Q _1012_/S VGND VGND VPWR VPWR _1011_/A sky130_fd_sc_hd__mux2_1
X_0725_ _1604_/Q VGND VGND VPWR VPWR _1397_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_57_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1208_ _1533_/Q _1208_/B _1208_/C _1208_/D VGND VGND VPWR VPWR _1208_/X sky130_fd_sc_hd__and4_1
X_1139_ _1139_/A VGND VGND VPWR VPWR _1507_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_40_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1490_ _1577_/CLK _1490_/D VGND VGND VPWR VPWR _1490_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold1 hold1/A VGND VGND VPWR VPWR hold1/X sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_39_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_238 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0990_ _1444_/Q _1443_/Q _0999_/S VGND VGND VPWR VPWR _0991_/A sky130_fd_sc_hd__mux2_1
XFILLER_8_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1611_ _1618_/CLK _1611_/D VGND VGND VPWR VPWR _1611_/Q sky130_fd_sc_hd__dfxtp_1
X_1542_ _1569_/CLK _1542_/D _0927_/B VGND VGND VPWR VPWR _1542_/Q sky130_fd_sc_hd__dfrtp_1
X_1473_ _1618_/CLK _1473_/D VGND VGND VPWR VPWR _1473_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_39_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_190 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_51_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_182 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0973_ _0973_/A _0973_/B _0973_/C VGND VGND VPWR VPWR _0973_/X sky130_fd_sc_hd__and3_1
X_1525_ _1600_/CLK _1525_/D repeater65/X VGND VGND VPWR VPWR _1525_/Q sky130_fd_sc_hd__dfrtp_1
X_1456_ _1487_/CLK _1456_/D _0932_/X VGND VGND VPWR VPWR _1456_/Q sky130_fd_sc_hd__dfstp_1
X_1387_ _1394_/A _1607_/Q _1431_/S _1608_/Q VGND VGND VPWR VPWR _1389_/B sky130_fd_sc_hd__a31o_1
XFILLER_27_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1241_ _1241_/A VGND VGND VPWR VPWR _1544_/D sky130_fd_sc_hd__clkbuf_1
X_1310_ _1239_/X _1567_/Q _1320_/S VGND VGND VPWR VPWR _1311_/A sky130_fd_sc_hd__mux2_1
XFILLER_1_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1172_ _1181_/A _1181_/B _1181_/C VGND VGND VPWR VPWR _1195_/A sky130_fd_sc_hd__and3_1
XFILLER_2_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0956_ _1478_/Q _0955_/A _0955_/Y _0967_/A VGND VGND VPWR VPWR _1478_/D sky130_fd_sc_hd__o211ai_1
XFILLER_17_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0887_ _1144_/S VGND VGND VPWR VPWR _1095_/S sky130_fd_sc_hd__clkbuf_4
X_1508_ _1569_/CLK _1508_/D VGND VGND VPWR VPWR _1508_/Q sky130_fd_sc_hd__dfxtp_1
X_1439_ _1442_/CLK _1439_/D repeater69/X VGND VGND VPWR VPWR _1439_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_2_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0810_ _1594_/Q _1594_/D VGND VGND VPWR VPWR _0811_/B sky130_fd_sc_hd__nand2_1
Xinput13 rst_n VGND VGND VPWR VPWR input13/X sky130_fd_sc_hd__buf_6
X_0741_ _1617_/Q _1616_/Q _1618_/Q _1467_/Q VGND VGND VPWR VPWR _1071_/D sky130_fd_sc_hd__nor4b_2
X_1224_ _1212_/X _1538_/Q _1234_/S VGND VGND VPWR VPWR _1225_/A sky130_fd_sc_hd__mux2_1
XFILLER_35_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1155_ _1515_/Q _1164_/B _1517_/Q VGND VGND VPWR VPWR _1181_/A sky130_fd_sc_hd__nor3_1
XFILLER_37_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1086_ _1086_/A _1086_/B VGND VGND VPWR VPWR _1086_/Y sky130_fd_sc_hd__nand2_1
X_0939_ _1587_/Q _1588_/Q VGND VGND VPWR VPWR _0939_/X sky130_fd_sc_hd__and2_1
XFILLER_32_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_122 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_81 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_8_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0724_ _0724_/A VGND VGND VPWR VPWR _0879_/B sky130_fd_sc_hd__buf_2
X_1207_ _1207_/A _1210_/C VGND VGND VPWR VPWR _1531_/D sky130_fd_sc_hd__nand2_1
X_1138_ _1507_/Q _1497_/Q _1138_/S VGND VGND VPWR VPWR _1139_/A sky130_fd_sc_hd__mux2_1
X_1069_ _1069_/A _1360_/B _1069_/C _1069_/D VGND VGND VPWR VPWR _1069_/Y sky130_fd_sc_hd__nor4_1
XFILLER_25_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold2 hold2/A VGND VGND VPWR VPWR hold2/X sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_30_294 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_206 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1610_ _1618_/CLK _1610_/D VGND VGND VPWR VPWR _1610_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_12_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1541_ _1569_/CLK _1541_/D repeater53/X VGND VGND VPWR VPWR _1541_/Q sky130_fd_sc_hd__dfrtp_1
X_1472_ _1618_/CLK _1472_/D VGND VGND VPWR VPWR _1472_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_54_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_5_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0972_ _1084_/B _0972_/B _0972_/C _1502_/Q VGND VGND VPWR VPWR _0972_/X sky130_fd_sc_hd__and4b_1
X_1524_ _1532_/CLK _1524_/D repeater65/X VGND VGND VPWR VPWR _1524_/Q sky130_fd_sc_hd__dfrtp_1
X_1455_ _1559_/CLK _1455_/D repeater49/X VGND VGND VPWR VPWR _1455_/Q sky130_fd_sc_hd__dfstp_1
X_1386_ _1386_/A VGND VGND VPWR VPWR _1607_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_23_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_58_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1171_ _1518_/Q VGND VGND VPWR VPWR _1181_/C sky130_fd_sc_hd__inv_2
X_1240_ _1239_/X _1544_/Q _1243_/S VGND VGND VPWR VPWR _1241_/A sky130_fd_sc_hd__mux2_1
XFILLER_1_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_0886_ _1123_/A VGND VGND VPWR VPWR _1144_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_32_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0955_ _0955_/A _1478_/Q VGND VGND VPWR VPWR _0955_/Y sky130_fd_sc_hd__nand2_1
XFILLER_20_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1507_ _1545_/CLK _1507_/D VGND VGND VPWR VPWR _1507_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_55_267 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1369_ _1369_/A VGND VGND VPWR VPWR _1601_/D sky130_fd_sc_hd__clkbuf_1
X_1438_ _1626_/CLK _1438_/D repeater72/X VGND VGND VPWR VPWR _1438_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_46_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput14 rx_j VGND VGND VPWR VPWR _1595_/D sky130_fd_sc_hd__dlymetal6s2s_1
X_0740_ _0740_/A VGND VGND VPWR VPWR _1431_/S sky130_fd_sc_hd__buf_2
XFILLER_14_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1154_ _1152_/X _1153_/Y _1150_/B VGND VGND VPWR VPWR _1516_/D sky130_fd_sc_hd__a21oi_1
X_1223_ _1243_/S VGND VGND VPWR VPWR _1234_/S sky130_fd_sc_hd__buf_2
XFILLER_37_212 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1085_ _0737_/A _1069_/Y input8/X _1052_/X VGND VGND VPWR VPWR _1086_/B sky130_fd_sc_hd__o2bb2ai_1
X_0938_ _1429_/S VGND VGND VPWR VPWR _0938_/X sky130_fd_sc_hd__clkbuf_2
X_0869_ _0929_/A VGND VGND VPWR VPWR _1370_/A sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_20_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_51_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_0723_ _1603_/Q _1601_/Q _1602_/Q VGND VGND VPWR VPWR _0724_/A sky130_fd_sc_hd__or3_1
X_1137_ _1137_/A VGND VGND VPWR VPWR _1506_/D sky130_fd_sc_hd__clkbuf_1
X_1206_ _1204_/X _1205_/Y _0915_/A VGND VGND VPWR VPWR _1207_/A sky130_fd_sc_hd__o21ai_1
X_1068_ _1084_/A _1084_/B VGND VGND VPWR VPWR _1068_/Y sky130_fd_sc_hd__nand2_1
XFILLER_48_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold3 hold3/A VGND VGND VPWR VPWR hold3/X sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_30_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_48_115 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1540_ _1569_/CLK _1540_/D repeater53/X VGND VGND VPWR VPWR _1540_/Q sky130_fd_sc_hd__dfrtp_1
X_1471_ _1532_/CLK _1471_/D VGND VGND VPWR VPWR _1471_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_5_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0971_ _0862_/X _1438_/Q _0968_/Y _0970_/X _0875_/X VGND VGND VPWR VPWR _1465_/D
+ sky130_fd_sc_hd__a311o_1
XFILLER_58_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1523_ _1600_/CLK _1523_/D repeater63/X VGND VGND VPWR VPWR _1523_/Q sky130_fd_sc_hd__dfrtp_1
X_1454_ _1559_/CLK _1454_/D repeater49/X VGND VGND VPWR VPWR _1454_/Q sky130_fd_sc_hd__dfstp_1
X_1385_ _1389_/A _1385_/B VGND VGND VPWR VPWR _1386_/A sky130_fd_sc_hd__and2_1
XFILLER_50_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_58_232 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1170_ _1168_/X _1169_/Y _1150_/B VGND VGND VPWR VPWR _1520_/D sky130_fd_sc_hd__a21oi_1
XFILLER_49_210 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_0885_ _0822_/A _0822_/B _0827_/A _1514_/Q _1546_/Q VGND VGND VPWR VPWR _1123_/A
+ sky130_fd_sc_hd__o2111a_1
X_0954_ _0967_/A _0955_/A _0954_/C VGND VGND VPWR VPWR _1477_/D sky130_fd_sc_hd__nand3_1
X_1506_ _1545_/CLK _1506_/D VGND VGND VPWR VPWR _1506_/Q sky130_fd_sc_hd__dfxtp_1
X_1437_ _1626_/CLK _1437_/D repeater72/X VGND VGND VPWR VPWR _1437_/Q sky130_fd_sc_hd__dfrtp_1
XFILLER_55_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1299_ _1299_/A VGND VGND VPWR VPWR _1562_/D sky130_fd_sc_hd__clkbuf_1
X_1368_ _1362_/Y _0930_/X _1376_/S VGND VGND VPWR VPWR _1369_/A sky130_fd_sc_hd__mux2_1
XFILLER_11_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput15 rx_se0 VGND VGND VPWR VPWR _1590_/D sky130_fd_sc_hd__clkbuf_1
X_1153_ _1164_/A _1164_/B VGND VGND VPWR VPWR _1153_/Y sky130_fd_sc_hd__nand2_1
X_1222_ _1222_/A _1222_/B _1222_/C _1222_/D VGND VGND VPWR VPWR _1243_/S sky130_fd_sc_hd__nand4_4
X_1084_ _1084_/A _1084_/B _1084_/C _1084_/D VGND VGND VPWR VPWR _1084_/Y sky130_fd_sc_hd__nand4_1
X_0937_ _0937_/A _1587_/Q VGND VGND VPWR VPWR _1587_/D sky130_fd_sc_hd__nand2_1
X_0799_ _1502_/Q _0968_/A _1535_/Q _1548_/Q VGND VGND VPWR VPWR _0970_/C sky130_fd_sc_hd__and4_1
X_0868_ _1603_/Q VGND VGND VPWR VPWR _0929_/A sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_43_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_64 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0722_ _1370_/B _1373_/A _0720_/Y _0721_/X VGND VGND VPWR VPWR _0722_/X sky130_fd_sc_hd__a211o_1
XFILLER_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1136_ _1506_/Q _1496_/Q _1138_/S VGND VGND VPWR VPWR _1137_/A sky130_fd_sc_hd__mux2_1
XFILLER_43_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1205_ _1531_/Q _1205_/B VGND VGND VPWR VPWR _1205_/Y sky130_fd_sc_hd__nor2_1
X_1067_ _1064_/X _1084_/C _1470_/Q _1073_/B VGND VGND VPWR VPWR _1470_/D sky130_fd_sc_hd__a22o_1
XFILLER_0_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_16_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_74 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1119_ _1498_/Q _1543_/Q _1121_/S VGND VGND VPWR VPWR _1120_/A sky130_fd_sc_hd__mux2_1
XFILLER_21_263 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_48_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1470_ _1618_/CLK _1470_/D VGND VGND VPWR VPWR _1470_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_50_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1599_ _1600_/CLK _1599_/D VGND VGND VPWR VPWR _1599_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_38_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0970_ _0879_/A _1084_/B _0970_/C _1037_/A VGND VGND VPWR VPWR _0970_/X sky130_fd_sc_hd__and4bb_1
X_1522_ _1625_/CLK _1522_/D repeater63/X VGND VGND VPWR VPWR _1522_/Q sky130_fd_sc_hd__dfrtp_1
X_1453_ _1559_/CLK _1453_/D repeater49/X VGND VGND VPWR VPWR _1453_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_27_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1384_ _1607_/Q _1384_/B VGND VGND VPWR VPWR _1385_/B sky130_fd_sc_hd__xnor2_1
XFILLER_50_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_7_0_clk_48 clkbuf_0_clk_48/X VGND VGND VPWR VPWR _1545_/CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_58_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_277 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0884_ _0972_/B _0882_/Y _0972_/C VGND VGND VPWR VPWR _0899_/C sky130_fd_sc_hd__o21ai_1
X_0953_ _1476_/Q _1477_/Q VGND VGND VPWR VPWR _0954_/C sky130_fd_sc_hd__nand2_1
X_1505_ _1545_/CLK _1505_/D VGND VGND VPWR VPWR _1505_/Q sky130_fd_sc_hd__dfxtp_1
X_1436_ _1442_/CLK _1436_/D repeater68/X VGND VGND VPWR VPWR _1436_/Q sky130_fd_sc_hd__dfrtp_1
X_1367_ _1372_/A _1402_/A _1372_/D VGND VGND VPWR VPWR _1376_/S sky130_fd_sc_hd__nand3_1
X_1298_ _1561_/Q _1562_/Q _1307_/S VGND VGND VPWR VPWR _1299_/A sky130_fd_sc_hd__mux2_1
XFILLER_23_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput16 usb_address[0] VGND VGND VPWR VPWR _0755_/A sky130_fd_sc_hd__clkbuf_1
XFILLER_6_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1221_ _0836_/X _0857_/X _0860_/X _1220_/Y VGND VGND VPWR VPWR _1537_/D sky130_fd_sc_hd__o31a_1
X_1152_ _1164_/A _1164_/B VGND VGND VPWR VPWR _1152_/X sky130_fd_sc_hd__or2_1
XFILLER_37_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1083_ _1080_/Y _1082_/X _1474_/Q _1061_/Y VGND VGND VPWR VPWR _1474_/D sky130_fd_sc_hd__o2bb2a_1
X_0936_ _1589_/Q _1357_/B VGND VGND VPWR VPWR _0937_/A sky130_fd_sc_hd__xor2_1
XFILLER_9_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0867_ _0973_/A _0973_/C VGND VGND VPWR VPWR _0867_/Y sky130_fd_sc_hd__nand2_1
X_0798_ _1253_/D _1439_/Q VGND VGND VPWR VPWR _0798_/X sky130_fd_sc_hd__and2b_1
XFILLER_57_18 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1419_ _1619_/Q _0938_/X _1159_/A _1335_/X VGND VGND VPWR VPWR _1619_/D sky130_fd_sc_hd__o22a_1
XFILLER_28_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_302 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0721_ _0934_/B _0721_/B _0721_/C _1626_/Q VGND VGND VPWR VPWR _0721_/X sky130_fd_sc_hd__and4_1
X_1204_ _1530_/Q _0911_/B _1529_/Q _1191_/A _1531_/Q VGND VGND VPWR VPWR _1204_/X
+ sky130_fd_sc_hd__o41a_1
XFILLER_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1135_ _1135_/A VGND VGND VPWR VPWR _1505_/D sky130_fd_sc_hd__clkbuf_1
X_1066_ _1049_/X _1052_/A _1041_/C _1078_/B VGND VGND VPWR VPWR _1073_/B sky130_fd_sc_hd__a31o_1
XFILLER_25_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0919_ _0859_/C _0826_/Y _0917_/X _0918_/X _1511_/Q VGND VGND VPWR VPWR _1513_/D
+ sky130_fd_sc_hd__a32o_1
XFILLER_0_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_32 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_42 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_47_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1118_ _1118_/A VGND VGND VPWR VPWR _1497_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_21_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1049_ _1049_/A _1054_/B VGND VGND VPWR VPWR _1049_/X sky130_fd_sc_hd__or2b_1
XFILLER_21_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_12_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_326 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_290 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1598_ _1600_/CLK _1598_/D VGND VGND VPWR VPWR _1598_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_53_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1521_ _1625_/CLK _1521_/D repeater62/X VGND VGND VPWR VPWR _1521_/Q sky130_fd_sc_hd__dfrtp_1
X_1452_ _1559_/CLK _1452_/D repeater49/X VGND VGND VPWR VPWR _1452_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_4_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1383_ _1383_/A VGND VGND VPWR VPWR _1606_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_23_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_289 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0952_ _1476_/Q _1477_/Q _0952_/C VGND VGND VPWR VPWR _0955_/A sky130_fd_sc_hd__or3_1
X_1504_ _1576_/CLK _1504_/D VGND VGND VPWR VPWR _1504_/Q sky130_fd_sc_hd__dfxtp_2
X_0883_ _0968_/A VGND VGND VPWR VPWR _0972_/C sky130_fd_sc_hd__dlymetal6s2s_1
X_1435_ _1442_/CLK _1435_/D repeater68/X VGND VGND VPWR VPWR _1435_/Q sky130_fd_sc_hd__dfstp_1
X_1366_ _1366_/A _1366_/B VGND VGND VPWR VPWR _1372_/D sky130_fd_sc_hd__nand2_1
XFILLER_23_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1297_ _1297_/A VGND VGND VPWR VPWR _1561_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_46_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput17 usb_address[1] VGND VGND VPWR VPWR _0945_/A sky130_fd_sc_hd__clkbuf_2
XFILLER_10_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1151_ _1516_/Q VGND VGND VPWR VPWR _1164_/B sky130_fd_sc_hd__dlymetal6s2s_1
X_1220_ _0857_/A _0860_/A _1032_/B VGND VGND VPWR VPWR _1220_/Y sky130_fd_sc_hd__o21bai_1
XFILLER_37_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1082_ input7/X _1052_/X _1063_/X _1084_/D VGND VGND VPWR VPWR _1082_/X sky130_fd_sc_hd__a2bb2o_1
X_0935_ _0935_/A VGND VGND VPWR VPWR _0935_/X sky130_fd_sc_hd__clkbuf_1
X_0866_ _1366_/A _0866_/B VGND VGND VPWR VPWR _0973_/C sky130_fd_sc_hd__nor2_1
X_0797_ _1222_/C VGND VGND VPWR VPWR _1253_/D sky130_fd_sc_hd__clkbuf_2
X_1349_ _1349_/A VGND VGND VPWR VPWR _1585_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_28_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1418_ _0783_/D _1402_/X _1395_/X VGND VGND VPWR VPWR _1618_/D sky130_fd_sc_hd__o21ai_1
XFILLER_36_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_11_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_314 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_119 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_229 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0720_ _0934_/B _0721_/B _0721_/C _1626_/Q VGND VGND VPWR VPWR _0720_/Y sky130_fd_sc_hd__a31oi_1
XFILLER_6_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1134_ _1505_/Q _1495_/Q _1138_/S VGND VGND VPWR VPWR _1135_/A sky130_fd_sc_hd__mux2_1
X_1203_ _1205_/B _1202_/Y _1149_/A VGND VGND VPWR VPWR _1530_/D sky130_fd_sc_hd__a21oi_1
XFILLER_26_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1065_ _0977_/D _1041_/C _1060_/B _1054_/Y VGND VGND VPWR VPWR _1084_/C sky130_fd_sc_hd__o211a_1
X_0918_ _0918_/A _0918_/B _0918_/C _1357_/B VGND VGND VPWR VPWR _0918_/X sky130_fd_sc_hd__and4_1
X_0849_ _0852_/A _1567_/Q _1571_/Q VGND VGND VPWR VPWR _0849_/Y sky130_fd_sc_hd__nor3b_1
XFILLER_56_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_44 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1117_ _1497_/Q _1542_/Q _1121_/S VGND VGND VPWR VPWR _1118_/A sky130_fd_sc_hd__mux2_1
X_1048_ _1078_/A _0973_/A _1360_/B _1047_/Y _0788_/X VGND VGND VPWR VPWR _1467_/D
+ sky130_fd_sc_hd__o221a_1
XFILLER_28_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_338 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1597_ _1597_/CLK hold2/X VGND VGND VPWR VPWR _1597_/Q sky130_fd_sc_hd__dfxtp_2
XFILLER_41_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_184 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1520_ _1625_/CLK _1520_/D repeater62/X VGND VGND VPWR VPWR _1520_/Q sky130_fd_sc_hd__dfrtp_1
X_1382_ _1389_/A _1382_/B _1384_/B VGND VGND VPWR VPWR _1383_/A sky130_fd_sc_hd__and3_1
X_1451_ _1559_/CLK _1451_/D repeater48/X VGND VGND VPWR VPWR _1451_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_35_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0882_ _1502_/Q VGND VGND VPWR VPWR _0882_/Y sky130_fd_sc_hd__inv_2
X_0951_ _1476_/Q _0952_/C _0967_/A VGND VGND VPWR VPWR _1476_/D sky130_fd_sc_hd__o21ai_1
XFILLER_20_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_56_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1503_ _1545_/CLK _1503_/D VGND VGND VPWR VPWR _1503_/Q sky130_fd_sc_hd__dfxtp_1
X_1434_ _1442_/CLK _1434_/D _1053_/B1 VGND VGND VPWR VPWR _1434_/Q sky130_fd_sc_hd__dfrtp_1
X_1365_ _1415_/B _1415_/C _1360_/Y _1364_/Y VGND VGND VPWR VPWR _1372_/A sky130_fd_sc_hd__a31o_1
X_1296_ _1560_/Q _1561_/Q _1307_/S VGND VGND VPWR VPWR _1297_/A sky130_fd_sc_hd__mux2_1
XFILLER_23_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_11_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_216 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput18 usb_address[2] VGND VGND VPWR VPWR _0752_/A sky130_fd_sc_hd__clkbuf_1
XFILLER_52_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1150_ _1164_/A _1150_/B VGND VGND VPWR VPWR _1515_/D sky130_fd_sc_hd__nor2_1
X_1081_ _1442_/Q VGND VGND VPWR VPWR _1084_/D sky130_fd_sc_hd__inv_2
X_0934_ _1360_/A _0934_/B _0934_/C VGND VGND VPWR VPWR _0935_/A sky130_fd_sc_hd__and3_1
XFILLER_9_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0865_ _1069_/C _0874_/B _0973_/B VGND VGND VPWR VPWR _0865_/X sky130_fd_sc_hd__or3_1
X_1417_ _1617_/Q _1402_/X _1618_/Q _1416_/X VGND VGND VPWR VPWR _1617_/D sky130_fd_sc_hd__o22a_1
X_0796_ _1436_/Q VGND VGND VPWR VPWR _0973_/A sky130_fd_sc_hd__dlymetal6s2s_1
X_1348_ _1585_/Q _1584_/Q _1424_/S VGND VGND VPWR VPWR _1349_/A sky130_fd_sc_hd__mux2_1
XFILLER_3_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1279_ _1279_/A VGND VGND VPWR VPWR _1553_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_51_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1133_ _1133_/A VGND VGND VPWR VPWR _1504_/D sky130_fd_sc_hd__clkbuf_1
X_1202_ _1529_/Q _1195_/Y _1530_/Q VGND VGND VPWR VPWR _1202_/Y sky130_fd_sc_hd__o21ai_1
XFILLER_19_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1064_ _0973_/B input3/X _0973_/C _1060_/A _1063_/X VGND VGND VPWR VPWR _1064_/X
+ sky130_fd_sc_hd__a41o_1
X_0917_ _1269_/B _1333_/S _1573_/Q VGND VGND VPWR VPWR _0917_/X sky130_fd_sc_hd__or3b_1
X_0848_ _0839_/Y _0846_/Y _0836_/X _0847_/Y VGND VGND VPWR VPWR _0854_/C sky130_fd_sc_hd__o211ai_2
X_0779_ _1613_/Q _1612_/Q VGND VGND VPWR VPWR _0783_/A sky130_fd_sc_hd__nor2_1
XFILLER_56_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_41 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_296 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_38_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1116_ _1116_/A VGND VGND VPWR VPWR _1496_/D sky130_fd_sc_hd__clkbuf_1
X_1047_ _1069_/C _1060_/A _1069_/D _1069_/A _0925_/X VGND VGND VPWR VPWR _1047_/Y
+ sky130_fd_sc_hd__a2111oi_1
XFILLER_21_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1596_ _1597_/CLK _1596_/D VGND VGND VPWR VPWR hold2/A sky130_fd_sc_hd__dfxtp_1
XFILLER_14_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xclkbuf_4_12_0_clk_48 clkbuf_0_clk_48/X VGND VGND VPWR VPWR _1587_/CLK sky130_fd_sc_hd__clkbuf_8
X_1450_ _1559_/CLK _1450_/D repeater48/X VGND VGND VPWR VPWR _1450_/Q sky130_fd_sc_hd__dfstp_1
X_1381_ _1397_/A _1605_/Q _1394_/A VGND VGND VPWR VPWR _1384_/B sky130_fd_sc_hd__or3b_1
XFILLER_35_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1579_ _1587_/CLK _1579_/D VGND VGND VPWR VPWR _1579_/Q sky130_fd_sc_hd__dfxtp_2
XTAP_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_155 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0950_ _0950_/A VGND VGND VPWR VPWR _0967_/A sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0881_ _1439_/Q VGND VGND VPWR VPWR _1037_/A sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_49_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1502_ _1587_/CLK _1502_/D VGND VGND VPWR VPWR _1502_/Q sky130_fd_sc_hd__dfxtp_2
X_1433_ _1442_/CLK _1433_/D repeater68/X VGND VGND VPWR VPWR _1433_/Q sky130_fd_sc_hd__dfrtp_1
X_1364_ _1373_/A _1601_/Q VGND VGND VPWR VPWR _1364_/Y sky130_fd_sc_hd__nand2_1
X_1295_ _1295_/A VGND VGND VPWR VPWR _1560_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput19 usb_address[3] VGND VGND VPWR VPWR _0754_/A sky130_fd_sc_hd__clkbuf_1
XFILLER_14_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1080_ _1080_/A _1474_/Q VGND VGND VPWR VPWR _1080_/Y sky130_fd_sc_hd__nand2_1
X_0933_ _1603_/Q VGND VGND VPWR VPWR _1360_/A sky130_fd_sc_hd__inv_2
X_0864_ input9/X VGND VGND VPWR VPWR _0973_/B sky130_fd_sc_hd__dlymetal6s2s_1
X_0795_ _1441_/Q VGND VGND VPWR VPWR _1084_/A sky130_fd_sc_hd__dlymetal6s2s_1
X_1347_ _1347_/A VGND VGND VPWR VPWR _1584_/D sky130_fd_sc_hd__clkbuf_1
X_1416_ _1360_/A _1370_/B _1373_/A _1415_/X _1398_/A VGND VGND VPWR VPWR _1416_/X
+ sky130_fd_sc_hd__a311o_1
X_1278_ _1552_/Q _1553_/Q _1278_/S VGND VGND VPWR VPWR _1279_/A sky130_fd_sc_hd__mux2_1
XFILLER_11_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_3_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_43 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_4_0_0_clk_48 clkbuf_0_clk_48/X VGND VGND VPWR VPWR _1559_/CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_6_176 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1201_ _1182_/B _1201_/B _1201_/C _1208_/C VGND VGND VPWR VPWR _1205_/B sky130_fd_sc_hd__nand4b_1
XFILLER_40_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1132_ _1504_/Q _1494_/Q _1138_/S VGND VGND VPWR VPWR _1133_/A sky130_fd_sc_hd__mux2_1
XFILLER_33_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1063_ _1084_/A _1084_/B _1433_/Q VGND VGND VPWR VPWR _1063_/X sky130_fd_sc_hd__and3_1
XFILLER_25_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0916_ _1239_/A VGND VGND VPWR VPWR _1269_/B sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_33_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_231 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_0778_ _1069_/C _0977_/D _1436_/Q VGND VGND VPWR VPWR _0778_/X sky130_fd_sc_hd__a21bo_1
XFILLER_0_319 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_0847_ _0838_/Y _0839_/Y _1579_/Q VGND VGND VPWR VPWR _0847_/Y sky130_fd_sc_hd__o21ai_2
XFILLER_56_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_53 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_58_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_201 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1115_ _1496_/Q _1541_/Q _1121_/S VGND VGND VPWR VPWR _1116_/A sky130_fd_sc_hd__mux2_1
XFILLER_0_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1046_ _1442_/Q _1084_/A VGND VGND VPWR VPWR _1078_/A sky130_fd_sc_hd__or2_1
XFILLER_21_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_88 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1595_ _1597_/CLK _1595_/D VGND VGND VPWR VPWR _1596_/D sky130_fd_sc_hd__dfxtp_1
XFILLER_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1029_ _1029_/A VGND VGND VPWR VPWR _1461_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_14_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_285 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1380_ _1394_/A _1431_/S VGND VGND VPWR VPWR _1382_/B sky130_fd_sc_hd__or2_1
XFILLER_35_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1578_ _1578_/CLK _1578_/D repeater47/X VGND VGND VPWR VPWR _1578_/Q sky130_fd_sc_hd__dfstp_1
XTAP_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_340 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_25_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_49_259 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_115 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0880_ _0742_/Y _1060_/A _0878_/Y _0879_/Y VGND VGND VPWR VPWR _0897_/B sky130_fd_sc_hd__o22a_1
X_1501_ _1587_/CLK _1501_/D VGND VGND VPWR VPWR _1501_/Q sky130_fd_sc_hd__dfxtp_1
X_1432_ _1432_/A VGND VGND VPWR VPWR _1626_/D sky130_fd_sc_hd__clkbuf_1
X_1363_ _1617_/Q _1616_/Q _1618_/Q VGND VGND VPWR VPWR _1415_/C sky130_fd_sc_hd__nor3_1
X_1294_ _1559_/Q _1560_/Q _1307_/S VGND VGND VPWR VPWR _1295_/A sky130_fd_sc_hd__mux2_1
XFILLER_11_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_240 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_14_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0932_ _0929_/X _0930_/X _0934_/C _0932_/B1 VGND VGND VPWR VPWR _0932_/X sky130_fd_sc_hd__o31a_2
X_0863_ _0857_/X _0860_/X _0862_/X _0826_/Y VGND VGND VPWR VPWR _1514_/D sky130_fd_sc_hd__a2bb2o_1
X_0794_ _1069_/A _1360_/B _1069_/D _1054_/C VGND VGND VPWR VPWR _0794_/X sky130_fd_sc_hd__or4b_1
X_1346_ _1584_/Q _1583_/Q _1424_/S VGND VGND VPWR VPWR _1347_/A sky130_fd_sc_hd__mux2_1
X_1415_ _1475_/Q _1415_/B _1415_/C VGND VGND VPWR VPWR _1415_/X sky130_fd_sc_hd__and3_1
X_1277_ _1275_/Y _1276_/X _1552_/Q _0830_/X VGND VGND VPWR VPWR _1552_/D sky130_fd_sc_hd__a2bb2o_1
XFILLER_11_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1200_ _0915_/A _1198_/Y _1199_/X _0918_/B VGND VGND VPWR VPWR _1529_/D sky130_fd_sc_hd__a31o_1
X_1131_ _1131_/A VGND VGND VPWR VPWR _1503_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_33_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1062_ input2/X _1052_/X _1060_/Y _1469_/Q _1061_/Y VGND VGND VPWR VPWR _1469_/D
+ sky130_fd_sc_hd__o32a_1
X_0915_ _0915_/A VGND VGND VPWR VPWR _0915_/Y sky130_fd_sc_hd__inv_2
XFILLER_33_287 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_33_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0777_ _1054_/B VGND VGND VPWR VPWR _0977_/D sky130_fd_sc_hd__clkbuf_2
X_0846_ _0838_/A _1597_/Q _0840_/Y VGND VGND VPWR VPWR _0846_/Y sky130_fd_sc_hd__o21ai_4
XFILLER_56_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1329_ _0918_/C _0938_/X _1576_/Q VGND VGND VPWR VPWR _1329_/X sky130_fd_sc_hd__a21o_1
XFILLER_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_65 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_213 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_53_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1114_ _1114_/A VGND VGND VPWR VPWR _1495_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_38_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1045_ _1037_/Y _1044_/A _1044_/Y VGND VGND VPWR VPWR _1466_/D sky130_fd_sc_hd__o21ai_1
X_0829_ _1309_/A VGND VGND VPWR VPWR _1333_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_21_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1594_ _1600_/CLK _1594_/D VGND VGND VPWR VPWR _1594_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_53_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1028_ _1461_/Q _1494_/Q _1030_/S VGND VGND VPWR VPWR _1029_/A sky130_fd_sc_hd__mux2_1
XFILLER_5_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1577_ _1577_/CLK _1577_/D _0928_/X VGND VGND VPWR VPWR _1577_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_41_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_69 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_149 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_57_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_1_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_127 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1500_ _1545_/CLK _1500_/D VGND VGND VPWR VPWR _1500_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_9_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1431_ _1626_/Q _0722_/X _1431_/S VGND VGND VPWR VPWR _1432_/A sky130_fd_sc_hd__mux2_1
X_1362_ _1370_/B _1373_/A _1360_/Y _1361_/Y VGND VGND VPWR VPWR _1362_/Y sky130_fd_sc_hd__a31oi_1
X_1293_ _1309_/A VGND VGND VPWR VPWR _1307_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_31_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_46_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_54_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0862_ _1357_/A VGND VGND VPWR VPWR _0862_/X sky130_fd_sc_hd__clkbuf_2
X_0931_ _0931_/A VGND VGND VPWR VPWR _0934_/C sky130_fd_sc_hd__clkbuf_2
XFILLER_54_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_0793_ _1434_/Q _1433_/Q VGND VGND VPWR VPWR _1054_/C sky130_fd_sc_hd__and2b_1
X_1345_ _1429_/S VGND VGND VPWR VPWR _1424_/S sky130_fd_sc_hd__clkbuf_2
X_1414_ _1616_/Q _1398_/A _1393_/A _1474_/Q _1413_/X VGND VGND VPWR VPWR _1616_/D
+ sky130_fd_sc_hd__a221o_1
X_1276_ _1260_/C _1551_/Q _1260_/B _1278_/S VGND VGND VPWR VPWR _1276_/X sky130_fd_sc_hd__a31o_1
XFILLER_51_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_211 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_36_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1130_ _1503_/Q _1493_/Q _1138_/S VGND VGND VPWR VPWR _1131_/A sky130_fd_sc_hd__mux2_1
X_1061_ _1049_/X _1052_/A _1060_/A _1080_/A VGND VGND VPWR VPWR _1061_/Y sky130_fd_sc_hd__a31oi_2
X_0914_ _1533_/Q _1208_/B _1208_/C _1208_/D VGND VGND VPWR VPWR _0915_/A sky130_fd_sc_hd__nand4b_4
XFILLER_33_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0845_ _1566_/Q _0843_/X _0844_/Y VGND VGND VPWR VPWR _0854_/B sky130_fd_sc_hd__o21ai_1
X_0776_ _1600_/Q _1599_/Q _1598_/Q _1467_/Q VGND VGND VPWR VPWR _1054_/B sky130_fd_sc_hd__nor4_1
X_1328_ _1252_/A _1252_/B _1575_/Q VGND VGND VPWR VPWR _1328_/Y sky130_fd_sc_hd__a21oi_1
X_1259_ _1565_/Q _1259_/B _1259_/C VGND VGND VPWR VPWR _1260_/C sky130_fd_sc_hd__nand3b_2
XFILLER_59_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1113_ _1495_/Q _1540_/Q _1121_/S VGND VGND VPWR VPWR _1114_/A sky130_fd_sc_hd__mux2_1
XFILLER_17_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1044_ _1044_/A _1466_/Q VGND VGND VPWR VPWR _1044_/Y sky130_fd_sc_hd__nand2_1
XFILLER_21_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0759_ _1506_/Q _0754_/A VGND VGND VPWR VPWR _0761_/C sky130_fd_sc_hd__or2b_1
X_0828_ _0822_/A _0822_/B _1429_/S VGND VGND VPWR VPWR _1309_/A sky130_fd_sc_hd__o21ai_4
XFILLER_29_303 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_56_177 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_44_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1593_ _1625_/CLK hold3/X VGND VGND VPWR VPWR _1594_/D sky130_fd_sc_hd__dfxtp_1
X_1027_ _1027_/A VGND VGND VPWR VPWR _1460_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_53_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1576_ _1576_/CLK _1576_/D _0928_/X VGND VGND VPWR VPWR _1576_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_58_206 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_32_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1430_ _1430_/A VGND VGND VPWR VPWR _1625_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_31_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_55_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1361_ _1373_/A _1370_/A _1370_/B VGND VGND VPWR VPWR _1361_/Y sky130_fd_sc_hd__a21oi_1
X_1292_ _1292_/A VGND VGND VPWR VPWR _1559_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_31_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1559_ _1559_/CLK _1559_/D repeater45/X VGND VGND VPWR VPWR _1559_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_54_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0861_ _1253_/D VGND VGND VPWR VPWR _1357_/A sky130_fd_sc_hd__clkbuf_2
X_0792_ _1599_/Q _1598_/Q VGND VGND VPWR VPWR _1069_/D sky130_fd_sc_hd__or2_1
X_0930_ _0930_/A VGND VGND VPWR VPWR _0930_/X sky130_fd_sc_hd__clkbuf_2
XFILLER_13_194 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1413_ _1370_/A _0930_/A _0931_/A _1617_/Q _1402_/A VGND VGND VPWR VPWR _1413_/X
+ sky130_fd_sc_hd__o311a_1
X_1344_ _1344_/A VGND VGND VPWR VPWR _1583_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_36_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_220 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1275_ _1260_/B _1260_/C _1551_/Q VGND VGND VPWR VPWR _1275_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_51_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_51_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_60 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1060_ _1060_/A _1060_/B VGND VGND VPWR VPWR _1060_/Y sky130_fd_sc_hd__nand2_1
X_0913_ _1532_/Q _1531_/Q VGND VGND VPWR VPWR _1208_/D sky130_fd_sc_hd__nor2_1
X_0844_ _1239_/A _1566_/Q _0843_/X VGND VGND VPWR VPWR _0844_/Y sky130_fd_sc_hd__o21ai_1
X_0775_ _1049_/A VGND VGND VPWR VPWR _1069_/C sky130_fd_sc_hd__dlymetal6s2s_1
X_1189_ _1191_/A _1526_/Q VGND VGND VPWR VPWR _1189_/Y sky130_fd_sc_hd__nand2_1
X_1327_ _1327_/A VGND VGND VPWR VPWR _1575_/D sky130_fd_sc_hd__clkbuf_1
X_1258_ _0839_/Y _0846_/Y _1565_/Q _0847_/Y VGND VGND VPWR VPWR _1260_/B sky130_fd_sc_hd__o211ai_4
XFILLER_24_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_59_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_15_0_clk_48 clkbuf_0_clk_48/X VGND VGND VPWR VPWR _1625_/CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_30_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1112_ _1112_/A VGND VGND VPWR VPWR _1494_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1043_ _1043_/A _1043_/B _1043_/C VGND VGND VPWR VPWR _1044_/A sky130_fd_sc_hd__nand3_1
XFILLER_9_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_94 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_0758_ _1503_/Q _0755_/A VGND VGND VPWR VPWR _0941_/C sky130_fd_sc_hd__or2b_1
X_0827_ _0827_/A VGND VGND VPWR VPWR _1429_/S sky130_fd_sc_hd__buf_2
XFILLER_56_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_337 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_315 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_28_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_318 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1592_ _1625_/CLK hold1/X VGND VGND VPWR VPWR hold3/A sky130_fd_sc_hd__dfxtp_1
X_1026_ _1460_/Q _1493_/Q _1030_/S VGND VGND VPWR VPWR _1027_/A sky130_fd_sc_hd__mux2_1
XFILLER_53_126 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_30_38 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_29_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_35_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1575_ _1577_/CLK _1575_/D _0928_/X VGND VGND VPWR VPWR _1575_/Q sky130_fd_sc_hd__dfstp_1
XANTENNA_0 _1465_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_58_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1009_ _1009_/A VGND VGND VPWR VPWR _1452_/D sky130_fd_sc_hd__clkbuf_1
XPHY_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_258 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_3_0_clk_48 clkbuf_0_clk_48/X VGND VGND VPWR VPWR _1597_/CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_25_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1360_ _1360_/A _1360_/B VGND VGND VPWR VPWR _1360_/Y sky130_fd_sc_hd__nand2_1
XFILLER_48_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_48_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1291_ _1558_/Q _1559_/Q _1291_/S VGND VGND VPWR VPWR _1292_/A sky130_fd_sc_hd__mux2_1
XFILLER_16_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1489_ _1577_/CLK _1489_/D VGND VGND VPWR VPWR _1489_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1558_ _1578_/CLK _1558_/D repeater44/X VGND VGND VPWR VPWR _1558_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_54_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_39_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0860_ _0860_/A VGND VGND VPWR VPWR _0860_/X sky130_fd_sc_hd__dlymetal6s2s_1
X_0791_ _1600_/Q VGND VGND VPWR VPWR _1069_/A sky130_fd_sc_hd__dlymetal6s2s_1
X_1343_ _1583_/Q _1582_/Q _1343_/S VGND VGND VPWR VPWR _1344_/A sky130_fd_sc_hd__mux2_1
XFILLER_3_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1412_ _1615_/Q _1398_/X _1393_/X _1473_/Q _1411_/X VGND VGND VPWR VPWR _1615_/D
+ sky130_fd_sc_hd__a221o_1
XFILLER_36_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_232 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1274_ _1274_/A VGND VGND VPWR VPWR _1551_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_51_257 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_0989_ _0989_/A VGND VGND VPWR VPWR _1443_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_6_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_176 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_12_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0912_ _1530_/Q _1529_/Q VGND VGND VPWR VPWR _1208_/C sky130_fd_sc_hd__nor2_2
X_0774_ _0774_/A _0774_/B _0774_/C VGND VGND VPWR VPWR _0774_/Y sky130_fd_sc_hd__nand3_1
X_0843_ _0852_/A _1570_/Q VGND VGND VPWR VPWR _0843_/X sky130_fd_sc_hd__or2b_1
X_1326_ _1574_/Q _1575_/Q _1333_/S VGND VGND VPWR VPWR _1327_/A sky130_fd_sc_hd__mux2_1
X_1188_ _1526_/Q _1191_/A VGND VGND VPWR VPWR _1188_/X sky130_fd_sc_hd__or2_1
X_1257_ _1548_/Q VGND VGND VPWR VPWR _1257_/Y sky130_fd_sc_hd__inv_2
XFILLER_33_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_82 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1111_ _1494_/Q _1539_/Q _1121_/S VGND VGND VPWR VPWR _1112_/A sky130_fd_sc_hd__mux2_1
XFILLER_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1042_ _1435_/Q _0895_/A _1040_/X _1439_/Q _1041_/Y VGND VGND VPWR VPWR _1043_/C
+ sky130_fd_sc_hd__a221oi_1
X_0757_ _0757_/A _1507_/Q VGND VGND VPWR VPWR _0943_/A sky130_fd_sc_hd__or2b_1
X_0826_ _1127_/B _1357_/C VGND VGND VPWR VPWR _0826_/Y sky130_fd_sc_hd__nand2_1
X_1309_ _1309_/A VGND VGND VPWR VPWR _1320_/S sky130_fd_sc_hd__clkbuf_2
XFILLER_29_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1591_ _1600_/CLK _1591_/D VGND VGND VPWR VPWR hold1/A sky130_fd_sc_hd__dfxtp_1
XFILLER_7_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_102 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1025_ _1025_/A VGND VGND VPWR VPWR _1459_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_53_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0809_ _1594_/Q _1594_/D _1591_/D VGND VGND VPWR VPWR _0811_/A sky130_fd_sc_hd__o21ai_1
XFILLER_29_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_1 input2/X VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_6_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1574_ _1577_/CLK _1574_/D _0928_/X VGND VGND VPWR VPWR _1574_/Q sky130_fd_sc_hd__dfstp_1
XTAP_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_26_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1008_ _1452_/Q _1451_/Q _1012_/S VGND VGND VPWR VPWR _1009_/A sky130_fd_sc_hd__mux2_1
XPHY_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1290_ _1290_/A VGND VGND VPWR VPWR _1558_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_23_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1626_ _1626_/CLK _1626_/D VGND VGND VPWR VPWR _1626_/Q sky130_fd_sc_hd__dfxtp_1
X_1488_ _1545_/CLK _1488_/D VGND VGND VPWR VPWR _1488_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1557_ _1559_/CLK _1557_/D repeater44/X VGND VGND VPWR VPWR _1557_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_54_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_26_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0790_ _0747_/Y _0774_/Y _0789_/X VGND VGND VPWR VPWR _1436_/D sky130_fd_sc_hd__o21ai_1
X_1342_ _1342_/A VGND VGND VPWR VPWR _1582_/D sky130_fd_sc_hd__clkbuf_1
X_1411_ _1370_/A _0930_/A _0931_/A _1616_/Q _1402_/A VGND VGND VPWR VPWR _1411_/X
+ sky130_fd_sc_hd__o311a_1
X_1273_ _1550_/Q _1551_/Q _1278_/S VGND VGND VPWR VPWR _1274_/A sky130_fd_sc_hd__mux2_1
XFILLER_51_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0988_ _1443_/Q _1020_/B _0999_/S VGND VGND VPWR VPWR _0989_/A sky130_fd_sc_hd__mux2_1
XFILLER_22_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1609_ _1626_/CLK _1609_/D VGND VGND VPWR VPWR _1609_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_47_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_269 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_321 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_288 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_19_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0911_ _1185_/A _0911_/B VGND VGND VPWR VPWR _1208_/B sky130_fd_sc_hd__nor2_2
XFILLER_33_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0842_ _0836_/X _1259_/B _1259_/C VGND VGND VPWR VPWR _0854_/A sky130_fd_sc_hd__nand3b_1
XFILLER_52_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_0773_ _0773_/A _0773_/B VGND VGND VPWR VPWR _0774_/C sky130_fd_sc_hd__nor2_1
X_1256_ _1246_/Y _1248_/Y _1255_/Y VGND VGND VPWR VPWR _1547_/D sky130_fd_sc_hd__o21ai_1
X_1325_ _1574_/Q _0830_/X _1324_/Y VGND VGND VPWR VPWR _1574_/D sky130_fd_sc_hd__a21o_1
X_1187_ _1191_/A _1186_/Y _1150_/B VGND VGND VPWR VPWR _1525_/D sky130_fd_sc_hd__a21oi_1
XFILLER_15_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_225 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1110_ _1144_/S VGND VGND VPWR VPWR _1121_/S sky130_fd_sc_hd__buf_2
XFILLER_48_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_98 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1041_ _1440_/Q _1041_/B _1041_/C VGND VGND VPWR VPWR _1041_/Y sky130_fd_sc_hd__nand3b_1
XFILLER_21_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0825_ _0803_/X _1127_/B _1159_/A _0824_/Y _1511_/Q VGND VGND VPWR VPWR _1511_/D
+ sky130_fd_sc_hd__a32o_1
X_0756_ _0942_/A _0941_/A _0942_/B _0941_/B VGND VGND VPWR VPWR _0762_/A sky130_fd_sc_hd__nand4_1
XFILLER_56_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1239_ _1239_/A _1566_/Q VGND VGND VPWR VPWR _1239_/X sky130_fd_sc_hd__or2_1
X_1308_ _1308_/A VGND VGND VPWR VPWR _1566_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_44_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_43_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_60 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_7_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1590_ _1625_/CLK _1590_/D VGND VGND VPWR VPWR _1591_/D sky130_fd_sc_hd__dfxtp_1
XFILLER_7_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_59_90 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1024_ _1459_/Q _1510_/Q _1030_/S VGND VGND VPWR VPWR _1025_/A sky130_fd_sc_hd__mux2_1
XFILLER_38_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_26_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0808_ _1222_/D VGND VGND VPWR VPWR _1127_/B sky130_fd_sc_hd__clkbuf_2
XFILLER_29_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0739_ _1604_/Q _1605_/Q VGND VGND VPWR VPWR _0740_/A sky130_fd_sc_hd__nor2_1
XFILLER_55_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_161 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_17_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1573_ _1576_/CLK _1573_/D VGND VGND VPWR VPWR _1573_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1007_ _1007_/A VGND VGND VPWR VPWR _1451_/D sky130_fd_sc_hd__clkbuf_1
XPHY_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_253 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_293 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1625_ _1625_/CLK _1625_/D repeater56/X VGND VGND VPWR VPWR _1625_/Q sky130_fd_sc_hd__dfrtp_1
X_1556_ _1559_/CLK _1556_/D repeater44/X VGND VGND VPWR VPWR _1556_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_39_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1487_ _1487_/CLK _1487_/D VGND VGND VPWR VPWR _1487_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_45_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_50 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_9_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1410_ _1614_/Q _1398_/X _1393_/X _1472_/Q _1409_/X VGND VGND VPWR VPWR _1614_/D
+ sky130_fd_sc_hd__a221o_1
X_1341_ _1582_/Q _1581_/Q _1343_/S VGND VGND VPWR VPWR _1342_/A sky130_fd_sc_hd__mux2_1
X_1272_ _1550_/Q _1127_/B _1271_/Y VGND VGND VPWR VPWR _1550_/D sky130_fd_sc_hd__o21ba_1
XFILLER_36_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0987_ _1021_/S VGND VGND VPWR VPWR _0999_/S sky130_fd_sc_hd__clkbuf_2
X_1539_ _1569_/CLK _1539_/D _0927_/B VGND VGND VPWR VPWR _1539_/Q sky130_fd_sc_hd__dfrtp_1
X_1608_ _1626_/CLK _1608_/D repeater71/X VGND VGND VPWR VPWR _1608_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_27_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_226 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_27_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_112 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_333 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_18_256 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_0772_ _0945_/A _0768_/Y _0943_/C _0943_/D _0941_/D VGND VGND VPWR VPWR _0773_/B
+ sky130_fd_sc_hd__o2111ai_1
X_0910_ _1526_/Q _1528_/Q _1527_/Q VGND VGND VPWR VPWR _0911_/B sky130_fd_sc_hd__or3_1
XFILLER_41_281 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_41_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0841_ _0838_/Y _0839_/Y _0840_/Y VGND VGND VPWR VPWR _1259_/C sky130_fd_sc_hd__o21ai_1
X_1186_ _1524_/Q _1523_/Q _1182_/B _1525_/Q VGND VGND VPWR VPWR _1186_/Y sky130_fd_sc_hd__o31ai_1
X_1255_ _1266_/B _1255_/B _1255_/C _1266_/C VGND VGND VPWR VPWR _1255_/Y sky130_fd_sc_hd__nand4_1
X_1324_ _1252_/A _1252_/B _0830_/X VGND VGND VPWR VPWR _1324_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_24_215 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_24_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_58_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_47_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_237 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_23_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1040_ _1535_/Q _1514_/Q _0968_/A VGND VGND VPWR VPWR _1040_/X sky130_fd_sc_hd__or3b_1
XFILLER_0_33 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_21_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0755_ _0755_/A _1503_/Q VGND VGND VPWR VPWR _0941_/B sky130_fd_sc_hd__or2b_1
X_0824_ _0918_/A _0918_/B _0918_/C _1357_/B VGND VGND VPWR VPWR _0824_/Y sky130_fd_sc_hd__nand4_1
XFILLER_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_332 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1169_ _1168_/B _1168_/C _1520_/Q VGND VGND VPWR VPWR _1169_/Y sky130_fd_sc_hd__o21ai_1
X_1238_ _1238_/A VGND VGND VPWR VPWR _1543_/D sky130_fd_sc_hd__clkbuf_1
X_1307_ _1242_/X _1566_/Q _1307_/S VGND VGND VPWR VPWR _1308_/A sky130_fd_sc_hd__mux2_1
XFILLER_12_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_284 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_55_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_72 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_50_71 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1023_ _0968_/A _0972_/B _0747_/Y VGND VGND VPWR VPWR _1030_/S sky130_fd_sc_hd__a21oi_4
X_0807_ _0822_/A _0822_/B _0827_/A VGND VGND VPWR VPWR _1222_/D sky130_fd_sc_hd__o21a_2
X_0738_ _1613_/Q _1612_/Q _1615_/Q _1614_/Q VGND VGND VPWR VPWR _1415_/B sky130_fd_sc_hd__nor4_4
XFILLER_39_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_52_173 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_40_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_173 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1572_ _1577_/CLK _1572_/D VGND VGND VPWR VPWR _1572_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1006_ _1451_/Q _1450_/Q _1012_/S VGND VGND VPWR VPWR _1007_/A sky130_fd_sc_hd__mux2_1
XPHY_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_34_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_265 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_57_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_129 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_15_63 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_31_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput40 _0879_/B VGND VGND VPWR VPWR tx_en sky130_fd_sc_hd__buf_2
XFILLER_31_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1624_ _1624_/CLK _1624_/D repeater58/X VGND VGND VPWR VPWR _1624_/Q sky130_fd_sc_hd__dfrtp_1
XTAP_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1555_ _1559_/CLK _1555_/D repeater44/X VGND VGND VPWR VPWR _1555_/Q sky130_fd_sc_hd__dfstp_1
XFILLER_39_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1486_ _1559_/CLK _1486_/D VGND VGND VPWR VPWR _1486_/Q sky130_fd_sc_hd__dfxtp_1
XFILLER_22_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_6_309 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_22_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_268 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_26_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_9_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1340_ _1340_/A VGND VGND VPWR VPWR _1581_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_36_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1271_ _1260_/B _1260_/C _1278_/S VGND VGND VPWR VPWR _1271_/Y sky130_fd_sc_hd__a21oi_1
XFILLER_44_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0986_ _1394_/B _1606_/Q _1609_/Q _1366_/B _0740_/A VGND VGND VPWR VPWR _1021_/S
+ sky130_fd_sc_hd__o221a_2
Xrepeater70 repeater71/X VGND VGND VPWR VPWR _0932_/B1 sky130_fd_sc_hd__clkbuf_2
XFILLER_59_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1538_ _1569_/CLK _1538_/D repeater52/X VGND VGND VPWR VPWR _1538_/Q sky130_fd_sc_hd__dfrtp_1
X_1469_ _1532_/CLK _1469_/D VGND VGND VPWR VPWR _1469_/Q sky130_fd_sc_hd__dfxtp_1
X_1607_ _1626_/CLK _1607_/D repeater71/X VGND VGND VPWR VPWR _1607_/Q sky130_fd_sc_hd__dfrtp_2
XFILLER_27_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_2_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0771_ _1509_/Q _0753_/A VGND VGND VPWR VPWR _0941_/D sky130_fd_sc_hd__or2b_1
XFILLER_41_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0840_ _1579_/Q VGND VGND VPWR VPWR _0840_/Y sky130_fd_sc_hd__inv_2
X_1323_ _1323_/A VGND VGND VPWR VPWR _1573_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_38_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_1185_ _1185_/A VGND VGND VPWR VPWR _1191_/A sky130_fd_sc_hd__dlymetal6s2s_1
X_1254_ _1253_/D _0859_/C _1222_/D _1222_/B _1222_/A VGND VGND VPWR VPWR _1266_/C
+ sky130_fd_sc_hd__o2111a_1
XFILLER_24_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0969_ _1434_/Q VGND VGND VPWR VPWR _1084_/B sky130_fd_sc_hd__clkbuf_2
XFILLER_59_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_9_32 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_0754_ _0754_/A _1506_/Q VGND VGND VPWR VPWR _0942_/B sky130_fd_sc_hd__or2b_1
X_0823_ _0823_/A VGND VGND VPWR VPWR _1357_/B sky130_fd_sc_hd__clkbuf_2
XFILLER_56_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1306_ _1304_/X _1127_/B _1260_/Y _1305_/Y VGND VGND VPWR VPWR _1565_/D sky130_fd_sc_hd__a31oi_1
XFILLER_52_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1099_ _1099_/A VGND VGND VPWR VPWR _1488_/D sky130_fd_sc_hd__clkbuf_1
X_1168_ _1520_/Q _1168_/B _1168_/C VGND VGND VPWR VPWR _1168_/X sky130_fd_sc_hd__or3_1
X_1237_ _1236_/X _1543_/Q _1243_/S VGND VGND VPWR VPWR _1238_/A sky130_fd_sc_hd__mux2_1
XFILLER_37_341 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_20_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_4_6_0_clk_48 clkbuf_0_clk_48/X VGND VGND VPWR VPWR _1576_/CLK sky130_fd_sc_hd__clkbuf_8
XFILLER_11_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_50_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_212 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_59_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1022_ _1022_/A VGND VGND VPWR VPWR _1458_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_19_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0806_ _1587_/Q _1588_/Q VGND VGND VPWR VPWR _0827_/A sky130_fd_sc_hd__nor2_1
XFILLER_39_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0737_ _0737_/A _1032_/B VGND VGND VPWR VPWR _0737_/X sky130_fd_sc_hd__xor2_1
XFILLER_55_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_44_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1571_ _1577_/CLK _1571_/D VGND VGND VPWR VPWR _1571_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_66 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_34_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1005_ _1005_/A VGND VGND VPWR VPWR _1450_/D sky130_fd_sc_hd__clkbuf_1
XFILLER_57_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_144 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_13_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput30 _1492_/Q VGND VGND VPWR VPWR data_out[7] sky130_fd_sc_hd__buf_2
Xoutput41 _0722_/X VGND VGND VPWR VPWR tx_j sky130_fd_sc_hd__buf_2
XFILLER_48_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_8_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1623_ _1625_/CLK _1623_/D repeater58/X VGND VGND VPWR VPWR _1623_/Q sky130_fd_sc_hd__dfrtp_1
XTAP_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1485_ _1487_/CLK _1485_/D VGND VGND VPWR VPWR _1485_/Q sky130_fd_sc_hd__dfxtp_1
XTAP_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_1554_ _1559_/CLK _1554_/D repeater44/X VGND VGND VPWR VPWR _1554_/Q sky130_fd_sc_hd__dfstp_1
.ends
